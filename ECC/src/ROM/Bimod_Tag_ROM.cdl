*
* Copyright 2012 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.3g
* Version: 2005Q2V1
* Name: High Speed/Density Diffusion ROM Generator (ROM-DIFF)|SMIC Logic013 Process
* Comment:
* Configuration:  -instname "Bimod_Tag_ROM" -words 128 -bits 16 -fr\
* Configuration: equency 5 -ring_width 5.0 -code_file "Bimod.rom" -\
* Configuration: mux 16 -top_layer "met5-8" -power_type rings -hori\
* Configuration: z met3 -vert met4 -cust_comment "" -bus_notation o\
* Configuration: n -left_bus_delim "[" -right_bus_delim "]" -pwr_gn\
* Configuration: d_rename "VDD:VDD,GND:VSS" -prefix "" -pin_space 0\
* Configuration: .0 -name_case upper -check_instname on -diodes on \
* Configuration: -inside_ring_type GND -drive 6 -corners ff_1.32_-4\
* Configuration: 0.0,tt_1.2_25.0,ss_1.08_125.0,ff_1.32_0.0
* Codefile: Bimod.rom
*
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT Bimod_Tag_ROMHXP38 A0 A1 A2 AGTPB AGTPT XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 VDD VSS
** Bimod_Tag_ROMHXP38: 189 flat devices **
d175 VSS A2 NDIO12 0.2116P 1.84U
d182 VSS A1 NDIO12 0.2116P 1.84U
d189 VSS A0 NDIO12 0.2116P 1.84U
m1 AP67-APN1 N31 AP67-AIND1 VSS N12 L=0.13U W=4.82U
m10 N26 AI2_ VSS VSS N12 L=0.13U W=2.02U
m100 AP23-AIND1 N109 VDD VDD P12 L=0.13U W=6.61U
m101 N141 N109 N142 VSS N12 L=0.13U W=4.82U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P12 L=0.13U W=6.61U
m103 AP23-AIND1 AP23-AIN21 N141 VSS N12 L=0.13U W=4.82U
m104 AP23-APN0 N126 AP23-AIND0 VSS N12 L=0.13U W=4.82U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P12 L=0.13U W=6.62U
m106 N126 AGTPB VDD VDD P12 L=0.13U W=0.94U
m107 N126 AGTPB VSS VSS N12 L=0.13U W=0.73U
m108 AP23-AIN20 AI0 VDD VDD P12 L=0.13U W=3.36U
m109 AP23-AIN20 AI0 VSS VSS N12 L=0.13U W=2.02U
m11 N60 N26 VSS VSS N12 L=0.13U W=4.82U
m110 N148 N110 VSS VSS N12 L=0.13U W=4.82U
m111 N147 N109 N148 VSS N12 L=0.13U W=4.82U
m112 AP23-AIND0 AP23-AIN20 N147 VSS N12 L=0.13U W=4.82U
m113 AP23-AIND0 N110 VDD VDD P12 L=0.13U W=6.61U
m114 N146 N110 VSS VSS N12 L=0.13U W=4.82U
m115 AP23-AIND0 N109 VDD VDD P12 L=0.13U W=6.61U
m116 N145 N109 N146 VSS N12 L=0.13U W=4.82U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P12 L=0.13U W=6.61U
m118 AP23-AIND0 AP23-AIN20 N145 VSS N12 L=0.13U W=4.82U
m119 AP23-APN1 XP_3 VDD VDD P12 L=0.2U W=0.15U
m12 N59 N25 N60 VSS N12 L=0.13U W=4.82U
m120 AP23-APN1 XP_3 VSS VSS N12 L=0.39U W=0.15U
m121 XP_3 AP23-APN1 VDD VDD P12 L=0.13U W=23.32U
m122 XP_3 AP23-APN1 VSS VSS N12 L=0.13U W=10.4U
m123 AP23-APN0 XP_2 VDD VDD P12 L=0.2U W=0.15U
m124 AP23-APN0 XP_2 VSS VSS N12 L=0.39U W=0.15U
m125 XP_2 AP23-APN0 VDD VDD P12 L=0.13U W=23.32U
m126 XP_2 AP23-APN0 VSS VSS N12 L=0.13U W=10.4U
m127 AP01-APN1 N157 AP01-AIND1 VSS N12 L=0.13U W=4.82U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P12 L=0.13U W=6.62U
m129 N157 AGTPT VDD VDD P12 L=0.13U W=0.94U
m13 AP67-AIND1 AP67-AIN21 N59 VSS N12 L=0.13U W=4.82U
m130 N157 AGTPT VSS VSS N12 L=0.13U W=0.73U
m131 AP01-AIN21 AI0_ VDD VDD P12 L=0.13U W=3.36U
m132 AP01-AIN21 AI0_ VSS VSS N12 L=0.13U W=2.02U
m133 N151 AI1 VDD VDD P12 L=0.13U W=3.36U
m134 N151 AI1 VSS VSS N12 L=0.13U W=2.02U
m135 N152 AI2 VDD VDD P12 L=0.13U W=3.36U
m136 N152 AI2 VSS VSS N12 L=0.13U W=2.02U
m137 N186 N152 VSS VSS N12 L=0.13U W=4.82U
m138 N185 N151 N186 VSS N12 L=0.13U W=4.82U
m139 AP01-AIND1 AP01-AIN21 N185 VSS N12 L=0.13U W=4.82U
m14 AP67-AIND1 N26 VDD VDD P12 L=0.13U W=6.61U
m140 AP01-AIND1 N152 VDD VDD P12 L=0.13U W=6.61U
m141 N184 N152 VSS VSS N12 L=0.13U W=4.82U
m142 AP01-AIND1 N151 VDD VDD P12 L=0.13U W=6.61U
m143 N183 N151 N184 VSS N12 L=0.13U W=4.82U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P12 L=0.13U W=6.61U
m145 AP01-AIND1 AP01-AIN21 N183 VSS N12 L=0.13U W=4.82U
m146 AP01-APN0 N168 AP01-AIND0 VSS N12 L=0.13U W=4.82U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P12 L=0.13U W=6.62U
m148 N168 AGTPB VDD VDD P12 L=0.13U W=0.94U
m149 N168 AGTPB VSS VSS N12 L=0.13U W=0.73U
m15 N58 N26 VSS VSS N12 L=0.13U W=4.82U
m150 AP01-AIN20 AI0 VDD VDD P12 L=0.13U W=3.36U
m151 AP01-AIN20 AI0 VSS VSS N12 L=0.13U W=2.02U
m152 N190 N152 VSS VSS N12 L=0.13U W=4.82U
m153 N189 N151 N190 VSS N12 L=0.13U W=4.82U
m154 AP01-AIND0 AP01-AIN20 N189 VSS N12 L=0.13U W=4.82U
m155 AP01-AIND0 N152 VDD VDD P12 L=0.13U W=6.61U
m156 N188 N152 VSS VSS N12 L=0.13U W=4.82U
m157 AP01-AIND0 N151 VDD VDD P12 L=0.13U W=6.61U
m158 N187 N151 N188 VSS N12 L=0.13U W=4.82U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P12 L=0.13U W=6.61U
m16 AP67-AIND1 N25 VDD VDD P12 L=0.13U W=6.61U
m160 AP01-AIND0 AP01-AIN20 N187 VSS N12 L=0.13U W=4.82U
m161 AP01-APN1 XP_1 VDD VDD P12 L=0.2U W=0.15U
m162 AP01-APN1 XP_1 VSS VSS N12 L=0.39U W=0.15U
m163 XP_1 AP01-APN1 VDD VDD P12 L=0.13U W=23.32U
m164 XP_1 AP01-APN1 VSS VSS N12 L=0.13U W=10.4U
m165 AP01-APN0 XP_0 VDD VDD P12 L=0.2U W=0.15U
m166 AP01-APN0 XP_0 VSS VSS N12 L=0.39U W=0.15U
m167 XP_0 AP01-APN0 VDD VDD P12 L=0.13U W=23.32U
m168 XP_0 AP01-APN0 VSS VSS N12 L=0.13U W=10.4U
m169 AI2 N191 VDD VDD P12 L=0.13U W=4U
m17 N57 N25 N58 VSS N12 L=0.13U W=4.82U
m170 AI2 N191 VSS VSS N12 L=0.13U W=2.46U
m171 AI2_ A2 VDD VDD P12 L=0.13U W=4U
m172 AI2_ A2 VSS VSS N12 L=0.13U W=2.46U
m173 N191 A2 VDD VDD P12 L=0.13U W=3.2U
m174 N191 A2 VSS VSS N12 L=0.13U W=1.98U
m176 AI1 N199 VDD VDD P12 L=0.13U W=4U
m177 AI1 N199 VSS VSS N12 L=0.13U W=2.46U
m178 AI1_ A1 VDD VDD P12 L=0.13U W=4U
m179 AI1_ A1 VSS VSS N12 L=0.13U W=2.46U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P12 L=0.13U W=6.61U
m180 N199 A1 VDD VDD P12 L=0.13U W=3.2U
m181 N199 A1 VSS VSS N12 L=0.13U W=1.98U
m183 AI0 N207 VDD VDD P12 L=0.13U W=4U
m184 AI0 N207 VSS VSS N12 L=0.13U W=2.46U
m185 AI0_ A0 VDD VDD P12 L=0.13U W=4U
m186 AI0_ A0 VSS VSS N12 L=0.13U W=2.46U
m187 N207 A0 VDD VDD P12 L=0.13U W=3.2U
m188 N207 A0 VSS VSS N12 L=0.13U W=1.98U
m19 AP67-AIND1 AP67-AIN21 N57 VSS N12 L=0.13U W=4.82U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P12 L=0.13U W=6.62U
m20 AP67-APN0 N42 AP67-AIND0 VSS N12 L=0.13U W=4.82U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P12 L=0.13U W=6.62U
m22 N42 AGTPB VDD VDD P12 L=0.13U W=0.94U
m23 N42 AGTPB VSS VSS N12 L=0.13U W=0.73U
m24 AP67-AIN20 AI0 VDD VDD P12 L=0.13U W=3.36U
m25 AP67-AIN20 AI0 VSS VSS N12 L=0.13U W=2.02U
m26 N64 N26 VSS VSS N12 L=0.13U W=4.82U
m27 N63 N25 N64 VSS N12 L=0.13U W=4.82U
m28 AP67-AIND0 AP67-AIN20 N63 VSS N12 L=0.13U W=4.82U
m29 AP67-AIND0 N26 VDD VDD P12 L=0.13U W=6.61U
m3 N31 AGTPT VDD VDD P12 L=0.13U W=0.94U
m30 N62 N26 VSS VSS N12 L=0.13U W=4.82U
m31 AP67-AIND0 N25 VDD VDD P12 L=0.13U W=6.61U
m32 N61 N25 N62 VSS N12 L=0.13U W=4.82U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P12 L=0.13U W=6.61U
m34 AP67-AIND0 AP67-AIN20 N61 VSS N12 L=0.13U W=4.82U
m35 AP67-APN1 XP_7 VDD VDD P12 L=0.2U W=0.15U
m36 AP67-APN1 XP_7 VSS VSS N12 L=0.39U W=0.15U
m37 XP_7 AP67-APN1 VDD VDD P12 L=0.13U W=23.32U
m38 XP_7 AP67-APN1 VSS VSS N12 L=0.13U W=10.4U
m39 AP67-APN0 XP_6 VDD VDD P12 L=0.2U W=0.15U
m4 N31 AGTPT VSS VSS N12 L=0.13U W=0.73U
m40 AP67-APN0 XP_6 VSS VSS N12 L=0.39U W=0.15U
m41 XP_6 AP67-APN0 VDD VDD P12 L=0.13U W=23.32U
m42 XP_6 AP67-APN0 VSS VSS N12 L=0.13U W=10.4U
m43 AP45-APN1 N73 AP45-AIND1 VSS N12 L=0.13U W=4.82U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P12 L=0.13U W=6.62U
m45 N73 AGTPT VDD VDD P12 L=0.13U W=0.94U
m46 N73 AGTPT VSS VSS N12 L=0.13U W=0.73U
m47 AP45-AIN21 AI0_ VDD VDD P12 L=0.13U W=3.36U
m48 AP45-AIN21 AI0_ VSS VSS N12 L=0.13U W=2.02U
m49 N67 AI1 VDD VDD P12 L=0.13U W=3.36U
m5 AP67-AIN21 AI0_ VDD VDD P12 L=0.13U W=3.36U
m50 N67 AI1 VSS VSS N12 L=0.13U W=2.02U
m51 N68 AI2_ VDD VDD P12 L=0.13U W=3.36U
m52 N68 AI2_ VSS VSS N12 L=0.13U W=2.02U
m53 N102 N68 VSS VSS N12 L=0.13U W=4.82U
m54 N101 N67 N102 VSS N12 L=0.13U W=4.82U
m55 AP45-AIND1 AP45-AIN21 N101 VSS N12 L=0.13U W=4.82U
m56 AP45-AIND1 N68 VDD VDD P12 L=0.13U W=6.61U
m57 N100 N68 VSS VSS N12 L=0.13U W=4.82U
m58 AP45-AIND1 N67 VDD VDD P12 L=0.13U W=6.61U
m59 N99 N67 N100 VSS N12 L=0.13U W=4.82U
m6 AP67-AIN21 AI0_ VSS VSS N12 L=0.13U W=2.02U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P12 L=0.13U W=6.61U
m61 AP45-AIND1 AP45-AIN21 N99 VSS N12 L=0.13U W=4.82U
m62 AP45-APN0 N84 AP45-AIND0 VSS N12 L=0.13U W=4.82U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P12 L=0.13U W=6.62U
m64 N84 AGTPB VDD VDD P12 L=0.13U W=0.94U
m65 N84 AGTPB VSS VSS N12 L=0.13U W=0.73U
m66 AP45-AIN20 AI0 VDD VDD P12 L=0.13U W=3.36U
m67 AP45-AIN20 AI0 VSS VSS N12 L=0.13U W=2.02U
m68 N106 N68 VSS VSS N12 L=0.13U W=4.82U
m69 N105 N67 N106 VSS N12 L=0.13U W=4.82U
m7 N25 AI1_ VDD VDD P12 L=0.13U W=3.36U
m70 AP45-AIND0 AP45-AIN20 N105 VSS N12 L=0.13U W=4.82U
m71 AP45-AIND0 N68 VDD VDD P12 L=0.13U W=6.61U
m72 N104 N68 VSS VSS N12 L=0.13U W=4.82U
m73 AP45-AIND0 N67 VDD VDD P12 L=0.13U W=6.61U
m74 N103 N67 N104 VSS N12 L=0.13U W=4.82U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P12 L=0.13U W=6.61U
m76 AP45-AIND0 AP45-AIN20 N103 VSS N12 L=0.13U W=4.82U
m77 AP45-APN1 XP_5 VDD VDD P12 L=0.2U W=0.15U
m78 AP45-APN1 XP_5 VSS VSS N12 L=0.39U W=0.15U
m79 XP_5 AP45-APN1 VDD VDD P12 L=0.13U W=23.32U
m8 N25 AI1_ VSS VSS N12 L=0.13U W=2.02U
m80 XP_5 AP45-APN1 VSS VSS N12 L=0.13U W=10.4U
m81 AP45-APN0 XP_4 VDD VDD P12 L=0.2U W=0.15U
m82 AP45-APN0 XP_4 VSS VSS N12 L=0.39U W=0.15U
m83 XP_4 AP45-APN0 VDD VDD P12 L=0.13U W=23.32U
m84 XP_4 AP45-APN0 VSS VSS N12 L=0.13U W=10.4U
m85 AP23-APN1 N115 AP23-AIND1 VSS N12 L=0.13U W=4.82U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P12 L=0.13U W=6.62U
m87 N115 AGTPT VDD VDD P12 L=0.13U W=0.94U
m88 N115 AGTPT VSS VSS N12 L=0.13U W=0.73U
m89 AP23-AIN21 AI0_ VDD VDD P12 L=0.13U W=3.36U
m9 N26 AI2_ VDD VDD P12 L=0.13U W=3.36U
m90 AP23-AIN21 AI0_ VSS VSS N12 L=0.13U W=2.02U
m91 N109 AI1_ VDD VDD P12 L=0.13U W=3.36U
m92 N109 AI1_ VSS VSS N12 L=0.13U W=2.02U
m93 N110 AI2 VDD VDD P12 L=0.13U W=3.36U
m94 N110 AI2 VSS VSS N12 L=0.13U W=2.02U
m95 N144 N110 VSS VSS N12 L=0.13U W=4.82U
m96 N143 N109 N144 VSS N12 L=0.13U W=4.82U
m97 AP23-AIND1 AP23-AIN21 N143 VSS N12 L=0.13U W=4.82U
m98 AP23-AIND1 N110 VDD VDD P12 L=0.13U W=6.61U
m99 N142 N110 VSS VSS N12 L=0.13U W=4.82U
.ENDS Bimod_Tag_ROMHXP38
****
.SUBCKT Bimod_Tag_ROMHXP38X A0 A1 A2 AGTPB AGTPT XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 VDD VSS
** Bimod_Tag_ROMHXP38X: 189 flat devices **
XI0 A0 A1 A2 AGTPB AGTPT XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 VDD VSS
+  Bimod_Tag_ROMHXP38
.ENDS Bimod_Tag_ROMHXP38X
****
.SUBCKT Bimod_Tag_ROMXDECS A0 A1 A2 AGTPB AGTPT XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 VDD VSS
** Bimod_Tag_ROMXDECS: 189 flat devices **
XI2 A0 A1 A2 AGTPB AGTPT XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 VDD VSS
+  Bimod_Tag_ROMHXP38X
.ENDS Bimod_Tag_ROMXDECS
****
.SUBCKT Bimod_Tag_ROMHYP12 A0 AGTPB AGTPT YP24_0 YP24_1 VDD VSS
** Bimod_Tag_ROMHYP12: 49 flat devices **
d49 VSS A0 NDIO12 0.2116P 1.84U
m1 AP-APN1 N20 AP-AIND1 VSS N12 L=0.13U W=4.82U
m10 N15 VSS VSS VSS N12 L=0.13U W=2.02U
m11 N49 N15 VSS VSS N12 L=0.13U W=4.82U
m12 N48 N14 N49 VSS N12 L=0.13U W=4.82U
m13 AP-AIND1 AP-AIN21 N48 VSS N12 L=0.13U W=4.82U
m14 AP-AIND1 N15 VDD VDD P12 L=0.13U W=6.61U
m15 N47 N15 VSS VSS N12 L=0.13U W=4.82U
m16 AP-AIND1 N14 VDD VDD P12 L=0.13U W=6.61U
m17 N46 N14 N47 VSS N12 L=0.13U W=4.82U
m18 AP-AIND1 AP-AIN21 VDD VDD P12 L=0.13U W=6.61U
m19 AP-AIND1 AP-AIN21 N46 VSS N12 L=0.13U W=4.82U
m2 AP-APN1 AGTPT AP-AIND1 VDD P12 L=0.13U W=6.62U
m20 AP-APN0 N31 AP-AIND0 VSS N12 L=0.13U W=4.82U
m21 AP-APN0 AGTPB AP-AIND0 VDD P12 L=0.13U W=6.62U
m22 N31 AGTPB VDD VDD P12 L=0.13U W=0.94U
m23 N31 AGTPB VSS VSS N12 L=0.13U W=0.73U
m24 AP-AIN20 N10 VDD VDD P12 L=0.13U W=3.36U
m25 AP-AIN20 N10 VSS VSS N12 L=0.13U W=2.02U
m26 N53 N15 VSS VSS N12 L=0.13U W=4.82U
m27 N52 N14 N53 VSS N12 L=0.13U W=4.82U
m28 AP-AIND0 AP-AIN20 N52 VSS N12 L=0.13U W=4.82U
m29 AP-AIND0 N15 VDD VDD P12 L=0.13U W=6.61U
m3 N20 AGTPT VDD VDD P12 L=0.13U W=0.94U
m30 N51 N15 VSS VSS N12 L=0.13U W=4.82U
m31 AP-AIND0 N14 VDD VDD P12 L=0.13U W=6.61U
m32 N50 N14 N51 VSS N12 L=0.13U W=4.82U
m33 AP-AIND0 AP-AIN20 VDD VDD P12 L=0.13U W=6.61U
m34 AP-AIND0 AP-AIN20 N50 VSS N12 L=0.13U W=4.82U
m35 AP-APN1 YP24_0 VDD VDD P12 L=0.2U W=0.15U
m36 AP-APN1 YP24_0 VSS VSS N12 L=0.39U W=0.15U
m37 YP24_0 AP-APN1 VDD VDD P12 L=0.13U W=23.32U
m38 YP24_0 AP-APN1 VSS VSS N12 L=0.13U W=10.4U
m39 AP-APN0 YP24_1 VDD VDD P12 L=0.2U W=0.15U
m4 N20 AGTPT VSS VSS N12 L=0.13U W=0.73U
m40 AP-APN0 YP24_1 VSS VSS N12 L=0.39U W=0.15U
m41 YP24_1 AP-APN0 VDD VDD P12 L=0.13U W=23.32U
m42 YP24_1 AP-APN0 VSS VSS N12 L=0.13U W=10.4U
m43 N9 N54 VDD VDD P12 L=0.13U W=4U
m44 N9 N54 VSS VSS N12 L=0.13U W=2.46U
m45 N10 A0 VDD VDD P12 L=0.13U W=4U
m46 N10 A0 VSS VSS N12 L=0.13U W=2.46U
m47 N54 A0 VDD VDD P12 L=0.13U W=3.2U
m48 N54 A0 VSS VSS N12 L=0.13U W=1.98U
m5 AP-AIN21 N9 VDD VDD P12 L=0.13U W=3.36U
m6 AP-AIN21 N9 VSS VSS N12 L=0.13U W=2.02U
m7 N14 VSS VDD VDD P12 L=0.13U W=3.36U
m8 N14 VSS VSS VSS N12 L=0.13U W=2.02U
m9 N15 VSS VDD VDD P12 L=0.13U W=3.36U
.ENDS Bimod_Tag_ROMHYP12
****
.SUBCKT Bimod_Tag_ROMHYP12X A0 AGTPB AGTPT YP24_0 YP24_1 VDD VSS
** Bimod_Tag_ROMHYP12X: 49 flat devices **
XI0 A0 AGTPB AGTPT YP24_0 YP24_1 VDD VSS Bimod_Tag_ROMHYP12
.ENDS Bimod_Tag_ROMHYP12X
****
.SUBCKT Bimod_Tag_ROMHYP38 A0 A1 A2 AGTPB AGTPT YP24_0 YP24_1 YP24_2 YP24_3
+  YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMHYP38: 189 flat devices **
d175 VSS A2 NDIO12 0.2116P 1.84U
d182 VSS A1 NDIO12 0.2116P 1.84U
d189 VSS A0 NDIO12 0.2116P 1.84U
m1 AP67-APN1 N35 AP67-AIND1 VSS N12 L=0.13U W=4.82U
m10 N30 AI2_ VSS VSS N12 L=0.13U W=2.02U
m100 AP23-AIND1 N113 VDD VDD P12 L=0.13U W=6.61U
m101 N145 N113 N146 VSS N12 L=0.13U W=4.82U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P12 L=0.13U W=6.61U
m103 AP23-AIND1 AP23-AIN21 N145 VSS N12 L=0.13U W=4.82U
m104 AP23-APN0 N130 AP23-AIND0 VSS N12 L=0.13U W=4.82U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P12 L=0.13U W=6.62U
m106 N130 AGTPB VDD VDD P12 L=0.13U W=0.94U
m107 N130 AGTPB VSS VSS N12 L=0.13U W=0.73U
m108 AP23-AIN20 AI0_ VDD VDD P12 L=0.13U W=3.36U
m109 AP23-AIN20 AI0_ VSS VSS N12 L=0.13U W=2.02U
m11 N64 N30 VSS VSS N12 L=0.13U W=4.82U
m110 N152 N114 VSS VSS N12 L=0.13U W=4.82U
m111 N151 N113 N152 VSS N12 L=0.13U W=4.82U
m112 AP23-AIND0 AP23-AIN20 N151 VSS N12 L=0.13U W=4.82U
m113 AP23-AIND0 N114 VDD VDD P12 L=0.13U W=6.61U
m114 N150 N114 VSS VSS N12 L=0.13U W=4.82U
m115 AP23-AIND0 N113 VDD VDD P12 L=0.13U W=6.61U
m116 N149 N113 N150 VSS N12 L=0.13U W=4.82U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P12 L=0.13U W=6.61U
m118 AP23-AIND0 AP23-AIN20 N149 VSS N12 L=0.13U W=4.82U
m119 AP23-APN1 YP38_2 VDD VDD P12 L=0.2U W=0.15U
m12 N63 N29 N64 VSS N12 L=0.13U W=4.82U
m120 AP23-APN1 YP38_2 VSS VSS N12 L=0.39U W=0.15U
m121 YP38_2 AP23-APN1 VDD VDD P12 L=0.13U W=23.32U
m122 YP38_2 AP23-APN1 VSS VSS N12 L=0.13U W=10.4U
m123 AP23-APN0 YP38_3 VDD VDD P12 L=0.2U W=0.15U
m124 AP23-APN0 YP38_3 VSS VSS N12 L=0.39U W=0.15U
m125 YP38_3 AP23-APN0 VDD VDD P12 L=0.13U W=23.32U
m126 YP38_3 AP23-APN0 VSS VSS N12 L=0.13U W=10.4U
m127 AP01-APN1 N161 AP01-AIND1 VSS N12 L=0.13U W=4.82U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P12 L=0.13U W=6.62U
m129 N161 AGTPT VDD VDD P12 L=0.13U W=0.94U
m13 AP67-AIND1 AP67-AIN21 N63 VSS N12 L=0.13U W=4.82U
m130 N161 AGTPT VSS VSS N12 L=0.13U W=0.73U
m131 AP01-AIN21 AI0 VDD VDD P12 L=0.13U W=3.36U
m132 AP01-AIN21 AI0 VSS VSS N12 L=0.13U W=2.02U
m133 N155 AI1 VDD VDD P12 L=0.13U W=3.36U
m134 N155 AI1 VSS VSS N12 L=0.13U W=2.02U
m135 N156 AI2 VDD VDD P12 L=0.13U W=3.36U
m136 N156 AI2 VSS VSS N12 L=0.13U W=2.02U
m137 N190 N156 VSS VSS N12 L=0.13U W=4.82U
m138 N189 N155 N190 VSS N12 L=0.13U W=4.82U
m139 AP01-AIND1 AP01-AIN21 N189 VSS N12 L=0.13U W=4.82U
m14 AP67-AIND1 N30 VDD VDD P12 L=0.13U W=6.61U
m140 AP01-AIND1 N156 VDD VDD P12 L=0.13U W=6.61U
m141 N188 N156 VSS VSS N12 L=0.13U W=4.82U
m142 AP01-AIND1 N155 VDD VDD P12 L=0.13U W=6.61U
m143 N187 N155 N188 VSS N12 L=0.13U W=4.82U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P12 L=0.13U W=6.61U
m145 AP01-AIND1 AP01-AIN21 N187 VSS N12 L=0.13U W=4.82U
m146 AP01-APN0 N172 AP01-AIND0 VSS N12 L=0.13U W=4.82U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P12 L=0.13U W=6.62U
m148 N172 AGTPB VDD VDD P12 L=0.13U W=0.94U
m149 N172 AGTPB VSS VSS N12 L=0.13U W=0.73U
m15 N62 N30 VSS VSS N12 L=0.13U W=4.82U
m150 AP01-AIN20 AI0_ VDD VDD P12 L=0.13U W=3.36U
m151 AP01-AIN20 AI0_ VSS VSS N12 L=0.13U W=2.02U
m152 N194 N156 VSS VSS N12 L=0.13U W=4.82U
m153 N193 N155 N194 VSS N12 L=0.13U W=4.82U
m154 AP01-AIND0 AP01-AIN20 N193 VSS N12 L=0.13U W=4.82U
m155 AP01-AIND0 N156 VDD VDD P12 L=0.13U W=6.61U
m156 N192 N156 VSS VSS N12 L=0.13U W=4.82U
m157 AP01-AIND0 N155 VDD VDD P12 L=0.13U W=6.61U
m158 N191 N155 N192 VSS N12 L=0.13U W=4.82U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P12 L=0.13U W=6.61U
m16 AP67-AIND1 N29 VDD VDD P12 L=0.13U W=6.61U
m160 AP01-AIND0 AP01-AIN20 N191 VSS N12 L=0.13U W=4.82U
m161 AP01-APN1 YP38_0 VDD VDD P12 L=0.2U W=0.15U
m162 AP01-APN1 YP38_0 VSS VSS N12 L=0.39U W=0.15U
m163 YP38_0 AP01-APN1 VDD VDD P12 L=0.13U W=23.32U
m164 YP38_0 AP01-APN1 VSS VSS N12 L=0.13U W=10.4U
m165 AP01-APN0 YP38_1 VDD VDD P12 L=0.2U W=0.15U
m166 AP01-APN0 YP38_1 VSS VSS N12 L=0.39U W=0.15U
m167 YP38_1 AP01-APN0 VDD VDD P12 L=0.13U W=23.32U
m168 YP38_1 AP01-APN0 VSS VSS N12 L=0.13U W=10.4U
m169 AI2 N195 VDD VDD P12 L=0.13U W=4U
m17 N61 N29 N62 VSS N12 L=0.13U W=4.82U
m170 AI2 N195 VSS VSS N12 L=0.13U W=2.46U
m171 AI2_ A2 VDD VDD P12 L=0.13U W=4U
m172 AI2_ A2 VSS VSS N12 L=0.13U W=2.46U
m173 N195 A2 VDD VDD P12 L=0.13U W=3.2U
m174 N195 A2 VSS VSS N12 L=0.13U W=1.98U
m176 AI1 N203 VDD VDD P12 L=0.13U W=4U
m177 AI1 N203 VSS VSS N12 L=0.13U W=2.46U
m178 AI1_ A1 VDD VDD P12 L=0.13U W=4U
m179 AI1_ A1 VSS VSS N12 L=0.13U W=2.46U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P12 L=0.13U W=6.61U
m180 N203 A1 VDD VDD P12 L=0.13U W=3.2U
m181 N203 A1 VSS VSS N12 L=0.13U W=1.98U
m183 AI0 N211 VDD VDD P12 L=0.13U W=4U
m184 AI0 N211 VSS VSS N12 L=0.13U W=2.46U
m185 AI0_ A0 VDD VDD P12 L=0.13U W=4U
m186 AI0_ A0 VSS VSS N12 L=0.13U W=2.46U
m187 N211 A0 VDD VDD P12 L=0.13U W=3.2U
m188 N211 A0 VSS VSS N12 L=0.13U W=1.98U
m19 AP67-AIND1 AP67-AIN21 N61 VSS N12 L=0.13U W=4.82U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P12 L=0.13U W=6.62U
m20 AP67-APN0 N46 AP67-AIND0 VSS N12 L=0.13U W=4.82U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P12 L=0.13U W=6.62U
m22 N46 AGTPB VDD VDD P12 L=0.13U W=0.94U
m23 N46 AGTPB VSS VSS N12 L=0.13U W=0.73U
m24 AP67-AIN20 AI0_ VDD VDD P12 L=0.13U W=3.36U
m25 AP67-AIN20 AI0_ VSS VSS N12 L=0.13U W=2.02U
m26 N68 N30 VSS VSS N12 L=0.13U W=4.82U
m27 N67 N29 N68 VSS N12 L=0.13U W=4.82U
m28 AP67-AIND0 AP67-AIN20 N67 VSS N12 L=0.13U W=4.82U
m29 AP67-AIND0 N30 VDD VDD P12 L=0.13U W=6.61U
m3 N35 AGTPT VDD VDD P12 L=0.13U W=0.94U
m30 N66 N30 VSS VSS N12 L=0.13U W=4.82U
m31 AP67-AIND0 N29 VDD VDD P12 L=0.13U W=6.61U
m32 N65 N29 N66 VSS N12 L=0.13U W=4.82U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P12 L=0.13U W=6.61U
m34 AP67-AIND0 AP67-AIN20 N65 VSS N12 L=0.13U W=4.82U
m35 AP67-APN1 YP38_6 VDD VDD P12 L=0.2U W=0.15U
m36 AP67-APN1 YP38_6 VSS VSS N12 L=0.39U W=0.15U
m37 YP38_6 AP67-APN1 VDD VDD P12 L=0.13U W=23.32U
m38 YP38_6 AP67-APN1 VSS VSS N12 L=0.13U W=10.4U
m39 AP67-APN0 YP38_7 VDD VDD P12 L=0.2U W=0.15U
m4 N35 AGTPT VSS VSS N12 L=0.13U W=0.73U
m40 AP67-APN0 YP38_7 VSS VSS N12 L=0.39U W=0.15U
m41 YP38_7 AP67-APN0 VDD VDD P12 L=0.13U W=23.32U
m42 YP38_7 AP67-APN0 VSS VSS N12 L=0.13U W=10.4U
m43 AP45-APN1 N77 AP45-AIND1 VSS N12 L=0.13U W=4.82U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P12 L=0.13U W=6.62U
m45 N77 AGTPT VDD VDD P12 L=0.13U W=0.94U
m46 N77 AGTPT VSS VSS N12 L=0.13U W=0.73U
m47 AP45-AIN21 AI0 VDD VDD P12 L=0.13U W=3.36U
m48 AP45-AIN21 AI0 VSS VSS N12 L=0.13U W=2.02U
m49 N71 AI1 VDD VDD P12 L=0.13U W=3.36U
m5 AP67-AIN21 AI0 VDD VDD P12 L=0.13U W=3.36U
m50 N71 AI1 VSS VSS N12 L=0.13U W=2.02U
m51 N72 AI2_ VDD VDD P12 L=0.13U W=3.36U
m52 N72 AI2_ VSS VSS N12 L=0.13U W=2.02U
m53 N106 N72 VSS VSS N12 L=0.13U W=4.82U
m54 N105 N71 N106 VSS N12 L=0.13U W=4.82U
m55 AP45-AIND1 AP45-AIN21 N105 VSS N12 L=0.13U W=4.82U
m56 AP45-AIND1 N72 VDD VDD P12 L=0.13U W=6.61U
m57 N104 N72 VSS VSS N12 L=0.13U W=4.82U
m58 AP45-AIND1 N71 VDD VDD P12 L=0.13U W=6.61U
m59 N103 N71 N104 VSS N12 L=0.13U W=4.82U
m6 AP67-AIN21 AI0 VSS VSS N12 L=0.13U W=2.02U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P12 L=0.13U W=6.61U
m61 AP45-AIND1 AP45-AIN21 N103 VSS N12 L=0.13U W=4.82U
m62 AP45-APN0 N88 AP45-AIND0 VSS N12 L=0.13U W=4.82U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P12 L=0.13U W=6.62U
m64 N88 AGTPB VDD VDD P12 L=0.13U W=0.94U
m65 N88 AGTPB VSS VSS N12 L=0.13U W=0.73U
m66 AP45-AIN20 AI0_ VDD VDD P12 L=0.13U W=3.36U
m67 AP45-AIN20 AI0_ VSS VSS N12 L=0.13U W=2.02U
m68 N110 N72 VSS VSS N12 L=0.13U W=4.82U
m69 N109 N71 N110 VSS N12 L=0.13U W=4.82U
m7 N29 AI1_ VDD VDD P12 L=0.13U W=3.36U
m70 AP45-AIND0 AP45-AIN20 N109 VSS N12 L=0.13U W=4.82U
m71 AP45-AIND0 N72 VDD VDD P12 L=0.13U W=6.61U
m72 N108 N72 VSS VSS N12 L=0.13U W=4.82U
m73 AP45-AIND0 N71 VDD VDD P12 L=0.13U W=6.61U
m74 N107 N71 N108 VSS N12 L=0.13U W=4.82U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P12 L=0.13U W=6.61U
m76 AP45-AIND0 AP45-AIN20 N107 VSS N12 L=0.13U W=4.82U
m77 AP45-APN1 YP38_4 VDD VDD P12 L=0.2U W=0.15U
m78 AP45-APN1 YP38_4 VSS VSS N12 L=0.39U W=0.15U
m79 YP38_4 AP45-APN1 VDD VDD P12 L=0.13U W=23.32U
m8 N29 AI1_ VSS VSS N12 L=0.13U W=2.02U
m80 YP38_4 AP45-APN1 VSS VSS N12 L=0.13U W=10.4U
m81 AP45-APN0 YP38_5 VDD VDD P12 L=0.2U W=0.15U
m82 AP45-APN0 YP38_5 VSS VSS N12 L=0.39U W=0.15U
m83 YP38_5 AP45-APN0 VDD VDD P12 L=0.13U W=23.32U
m84 YP38_5 AP45-APN0 VSS VSS N12 L=0.13U W=10.4U
m85 AP23-APN1 N119 AP23-AIND1 VSS N12 L=0.13U W=4.82U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P12 L=0.13U W=6.62U
m87 N119 AGTPT VDD VDD P12 L=0.13U W=0.94U
m88 N119 AGTPT VSS VSS N12 L=0.13U W=0.73U
m89 AP23-AIN21 AI0 VDD VDD P12 L=0.13U W=3.36U
m9 N30 AI2_ VDD VDD P12 L=0.13U W=3.36U
m90 AP23-AIN21 AI0 VSS VSS N12 L=0.13U W=2.02U
m91 N113 AI1_ VDD VDD P12 L=0.13U W=3.36U
m92 N113 AI1_ VSS VSS N12 L=0.13U W=2.02U
m93 N114 AI2 VDD VDD P12 L=0.13U W=3.36U
m94 N114 AI2 VSS VSS N12 L=0.13U W=2.02U
m95 N148 N114 VSS VSS N12 L=0.13U W=4.82U
m96 N147 N113 N148 VSS N12 L=0.13U W=4.82U
m97 AP23-AIND1 AP23-AIN21 N147 VSS N12 L=0.13U W=4.82U
m98 AP23-AIND1 N114 VDD VDD P12 L=0.13U W=6.61U
m99 N146 N114 VSS VSS N12 L=0.13U W=4.82U
.ENDS Bimod_Tag_ROMHYP38
****
.SUBCKT Bimod_Tag_ROMHYP38X A0 A1 A2 AGTPB AGTPT YP24_0 YP24_1 YP24_2 YP24_3
+  YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMHYP38X: 189 flat devices **
XI0 A0 A1 A2 AGTPB AGTPT YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMHYP38
.ENDS Bimod_Tag_ROMHYP38X
****
.SUBCKT Bimod_Tag_ROMYDECS A0_0 A0_1 A1 A2 AGTPB AGTPT YP24_0 YP24_1 YP38_0
+  YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMYDECS: 238 flat devices **
XI0 A0_0 AGTPB AGTPT YP24_0 YP24_1 VDD VSS Bimod_Tag_ROMHYP12X
XI1 A0_1 A1 A2 AGTPB AGTPT YP24_0 YP24_1 VSS VSS YP38_0 YP38_1 YP38_2 YP38_3
+  YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMHYP38X
.ENDS Bimod_Tag_ROMYDECS
****
.SUBCKT Bimod_Tag_ROMXYDECS A0_0 A0_1 A0_2 A1_0 A1_1 A2_0 A2_1 AGTPB AGTPT
+  XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP24_0 YP24_1 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMXYDECS: 427 flat devices **
XI0 A0_0 A1_0 A2_0 AGTPB AGTPT XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 VDD VSS
+  Bimod_Tag_ROMXDECS
XI1 A0_1 A0_2 A1_1 A2_1 AGTPB AGTPT YP24_0 YP24_1 YP38_0 YP38_1 YP38_2 YP38_3
+  YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMYDECS
.ENDS Bimod_Tag_ROMXYDECS
****
.SUBCKT Bimod_Tag_ROMHBF16 CEN CLK GSRCN GTP GTPN MBL RST STOV VDD VSS
** Bimod_Tag_ROMHBF16: 76 flat devices **
d74 VSS CEN NDIO12 0.2116P 1.84U
d75 VSS STOV NDIO12 0.2116P 1.84U
d76 VSS CLK NDIO12 0.2116P 1.84U
m1 BF-CEL BF-CENMML VDD VDD P12 L=0.13U W=3.02U
m10 BF-CKSTOV CLK N77 VSS N12 L=0.13U W=2.64U
m11 GTPN BF-GTPI N33 VSS N12 L=0.13U W=0.15U
m12 N18 N18 VDD VDD P12 L=0.13U W=0.15U
m13 GTPN BF-GTPI VDD VDD P12 L=0.13U W=0.3U
m14 N18 VDD VDD VDD P12 L=0.13U W=0.15U
m15 BF-GTPI GTPN VDD VDD P12 L=0.13U W=0.3U
m16 BF-GTPI GTPN VSS VSS N12 L=0.13U W=0.15U
m17 N33 N18 VSS VSS N12 L=0.13U W=0.15U
m18 N79 BF-CLKN VSS VSS N12 L=0.13U W=5.33U
m19 GSRCN BF-CEL N79 VSS N12 L=0.13U W=5.33U
m2 BF-CEL BF-CENMML VSS VSS N12 L=0.13U W=1.96U
m20 GSRCN BF-CLKN VDD VDD P12 L=0.13U W=7.32U
m21 N78 BF-CLKN VSS VSS N12 L=0.13U W=5.33U
m22 GSRCN BF-CEL VDD VDD P12 L=0.13U W=7.32U
m23 GSRCN BF-CEL N78 VSS N12 L=0.13U W=5.33U
m24 N42 BF-CLKN VSS VSS N12 L=0.13U W=1.07U
m25 N44 CLK VDD VDD P12 L=0.13U W=1.46U
m26 BF-CENMML N46 N44 VDD P12 L=0.13U W=1.46U
m27 BF-CENMML N46 N42 VSS N12 L=0.13U W=1.07U
m28 RST BF-MBLN VDD VDD P12 L=0.13U W=2.26U
m29 RST BF-RSTSRC VDD VDD P12 L=0.13U W=26.25U
m3 BF-CLKN CLK VDD VDD P12 L=0.13U W=3.52U
m30 N46 CEN VDD VDD P12 L=0.13U W=0.66U
m31 N46 CEN VSS VSS N12 L=0.13U W=0.4U
m32 RST BF-MBLN N87 VSS N12 L=0.13U W=4.98U
m33 N87 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m34 RST BF-MBLN N86 VSS N12 L=0.13U W=4.98U
m35 N86 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m36 RST BF-MBLN N85 VSS N12 L=0.13U W=4.98U
m37 N85 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m38 RST BF-MBLN N84 VSS N12 L=0.13U W=4.98U
m39 N84 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m4 BF-CLKN CLK VSS VSS N12 L=0.13U W=1.06U
m40 RST BF-MBLN N83 VSS N12 L=0.13U W=4.98U
m41 N83 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m42 RST BF-MBLN N82 VSS N12 L=0.13U W=4.98U
m43 N82 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m44 RST BF-MBLN N81 VSS N12 L=0.13U W=4.98U
m45 N81 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m46 RST BF-MBLN N80 VSS N12 L=0.13U W=4.98U
m47 N80 BF-RSTSRC VSS VSS N12 L=0.13U W=6.47U
m48 BF-CENMML CLK N51 VSS N12 L=0.26U W=0.3U
m49 N52 BF-CEL VDD VDD P12 L=0.26U W=0.3U
m5 BF-RSTSRC BF-RSRCN VDD VDD P12 L=0.13U W=15.3U
m50 N51 BF-CEL VSS VSS N12 L=0.26U W=0.3U
m51 BF-CENMML BF-CLKN N52 VDD P12 L=0.26U W=0.3U
m52 BF-RSRCN BF-CKSTOV N55 VSS N12 L=0.13U W=6.22U
m53 BF-RSRCN GTP VDD VDD P12 L=0.13U W=2.67U
m54 N55 GTP VSS VSS N12 L=0.13U W=6.22U
m55 BF-RSRCN GTP VDD VDD P12 L=0.13U W=2.67U
m56 BF-RSRCN BF-CKSTOV VDD VDD P12 L=0.13U W=2.67U
m57 BF-RSRCN BF-CKSTOV VDD VDD P12 L=0.13U W=2.67U
m58 N24 STOV VDD VDD P12 L=0.13U W=1.08U
m59 N24 STOV VSS VSS N12 L=0.13U W=0.88U
m6 BF-RSTSRC BF-RSRCN VSS VSS N12 L=0.13U W=8.92U
m60 N63 BF-RSTSRC VDD VDD P12 L=0.13U W=1.56U
m61 RST N24 N63 VDD P12 L=0.13U W=1.56U
m62 N65 BF-RSTSRC VSS VSS N12 L=0.13U W=1.28U
m63 RST STOV N65 VSS N12 L=0.13U W=1.28U
m64 N67 MBL VDD VDD P12 L=0.13U W=3.28U
m65 BF-MBLN STOV N67 VDD P12 L=0.13U W=3.28U
m66 BF-MBLN N24 N69 VSS N12 L=0.13U W=3U
m67 N69 MBL VSS VSS N12 L=0.13U W=3U
m68 N71 BF-RSTSRC VDD VDD P12 L=0.13U W=1.56U
m69 RST N24 N71 VDD P12 L=0.13U W=1.56U
m7 BF-CKSTOV STOV VDD VDD P12 L=0.13U W=2.27U
m70 RST STOV N73 VSS N12 L=0.13U W=1.28U
m71 N73 BF-RSTSRC VSS VSS N12 L=0.13U W=1.28U
m72 N75 MBL VDD VDD P12 L=0.13U W=3.28U
m73 BF-MBLN STOV N75 VDD P12 L=0.13U W=3.28U
m8 N77 STOV VSS VSS N12 L=0.13U W=2.64U
m9 BF-CKSTOV CLK VDD VDD P12 L=0.13U W=2.27U
.ENDS Bimod_Tag_ROMHBF16
****
.SUBCKT Bimod_Tag_ROMHBFX CEN CLK GSRCN GTP GTPN MBL RST VDD VSS
** Bimod_Tag_ROMHBFX: 76 flat devices **
XI0 CEN CLK GSRCN GTP GTPN MBL RST VSS VDD VSS Bimod_Tag_ROMHBF16
.ENDS Bimod_Tag_ROMHBFX
****
.SUBCKT Bimod_Tag_ROMWD G0_0 G0_1 G0_2 G0_3 GTP WL0 WL1 WL2 WL3 XP0_0 XP0_1
+  XP0_2 XP0_3 XP0_4 XP0_5 XP0_6 XP0_7 XP1 XP2 XPX VDD VSS
** Bimod_Tag_ROMWD: 54 flat devices **
m1 N24 RSWN0 GTP VDD P12 L=0.13U W=1.54U
m10 WL1 WL1_EN_ VDD VDD P12 L=0.13U W=25.02U
m11 WL1 WL1_EN_ VSS VSS N12 L=0.13U W=11.12U
m12 N28 RSWN1 VSS VSS N12 L=0.13U W=0.3U
m13 WL1_EN_ N28 VDD VDD P12 L=0.13U W=8.86U
m14 WL1_EN_ N28 VSS VSS N12 L=0.13U W=5.16U
m15 WL2 WL2_EN_ VDD VDD P12 L=0.13U W=25.02U
m16 WL2 WL2_EN_ VSS VSS N12 L=0.13U W=11.12U
m17 WL2_EN_ N35 VDD VDD P12 L=0.13U W=8.86U
m18 WL2_EN_ N35 VSS VSS N12 L=0.13U W=5.16U
m19 WL3 WL3_EN_ VDD VDD P12 L=0.13U W=25.02U
m2 N24 N25 GTP VSS N12 L=0.13U W=1.4U
m20 WL3 WL3_EN_ VSS VSS N12 L=0.13U W=11.12U
m21 WL3_EN_ N38 VDD VDD P12 L=0.13U W=8.86U
m22 WL3_EN_ N38 VSS VSS N12 L=0.13U W=5.16U
m23 N58 XP1 VSS VSS N12 L=0.13U W=0.87U
m24 N32 XP2 N58 VSS N12 L=0.13U W=0.87U
m25 RSWN3 G0_3 VDD VDD P12 L=0.13U W=0.72U
m26 RSWN3 G0_3 N32 VSS N12 L=0.13U W=0.72U
m27 RSWN3 XP2 VDD VDD P12 L=0.13U W=0.72U
m28 RSWN3 XP1 VDD VDD P12 L=0.13U W=0.72U
m29 RSWN2 XP1 VDD VDD P12 L=0.13U W=0.72U
m3 WL0 WL0_EN_ VDD VDD P12 L=0.13U W=25.02U
m30 RSWN2 XP2 VDD VDD P12 L=0.13U W=0.72U
m31 RSWN2 G0_2 VDD VDD P12 L=0.13U W=0.72U
m32 RSWN2 G0_2 N32 VSS N12 L=0.13U W=0.72U
m33 RSWN0 G0_0 VDD VDD P12 L=0.13U W=0.72U
m34 RSWN0 G0_0 N32 VSS N12 L=0.13U W=0.72U
m35 RSWN0 XP1 VDD VDD P12 L=0.13U W=0.72U
m36 RSWN0 XP2 VDD VDD P12 L=0.13U W=0.72U
m37 RSWN1 XP2 VDD VDD P12 L=0.13U W=0.72U
m38 RSWN1 XP1 VDD VDD P12 L=0.13U W=0.72U
m39 RSWN1 G0_1 VDD VDD P12 L=0.13U W=0.72U
m4 WL0 WL0_EN_ VSS VSS N12 L=0.13U W=11.12U
m40 RSWN1 G0_1 N32 VSS N12 L=0.13U W=0.72U
m41 N25 RSWN0 VDD VDD P12 L=0.13U W=0.35U
m42 N25 RSWN0 VSS VSS N12 L=0.13U W=0.2U
m43 N29 RSWN1 VDD VDD P12 L=0.13U W=0.35U
m44 N29 RSWN1 VSS VSS N12 L=0.13U W=0.2U
m45 N35 RSWN2 GTP VDD P12 L=0.13U W=1.54U
m46 N35 N36 GTP VSS N12 L=0.13U W=1.4U
m47 N35 RSWN2 VSS VSS N12 L=0.13U W=0.3U
m48 N38 RSWN3 GTP VDD P12 L=0.13U W=1.54U
m49 N38 N39 GTP VSS N12 L=0.13U W=1.4U
m5 N24 RSWN0 VSS VSS N12 L=0.13U W=0.3U
m50 N38 RSWN3 VSS VSS N12 L=0.13U W=0.3U
m51 N36 RSWN2 VDD VDD P12 L=0.13U W=0.35U
m52 N36 RSWN2 VSS VSS N12 L=0.13U W=0.2U
m53 N39 RSWN3 VDD VDD P12 L=0.13U W=0.35U
m54 N39 RSWN3 VSS VSS N12 L=0.13U W=0.2U
m6 WL0_EN_ N24 VDD VDD P12 L=0.13U W=8.86U
m7 WL0_EN_ N24 VSS VSS N12 L=0.13U W=5.16U
m8 N28 RSWN1 GTP VDD P12 L=0.13U W=1.54U
m9 N28 N29 GTP VSS N12 L=0.13U W=1.4U
.ENDS Bimod_Tag_ROMWD
****
.SUBCKT Bimod_Tag_ROMWDXR0 GTP WL0 WL1 WL2 WL3 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP0_6 XP0_7 XP1 XP2 VDD VSS
** Bimod_Tag_ROMWDXR0: 54 flat devices **
XI0 XP0_0 XP0_1 XP0_2 XP0_3 GTP WL0 WL1 WL2 WL3 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP0_6 XP0_7 XP1 XP2 XP1 VDD VSS Bimod_Tag_ROMWD
.ENDS Bimod_Tag_ROMWDXR0
****
.SUBCKT Bimod_Tag_ROMWDXMX GTP WL0 WL1 WL2 WL3 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP0_6 XP0_7 XP1 XP2 VDD VSS
** Bimod_Tag_ROMWDXMX: 54 flat devices **
XI0 XP0_7 XP0_6 XP0_5 XP0_4 GTP WL0 WL1 WL2 WL3 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4
+  XP0_5 XP0_6 XP0_7 XP1 XP2 XP2 VDD VSS Bimod_Tag_ROMWD
.ENDS Bimod_Tag_ROMWDXMX
****
.SUBCKT Bimod_Tag_ROMMWD GTP MA0 MA1 MBL MWG0 MWG1 MWG2 MWG3 MWG4 MWG5 MWG6
+  MWG7 MWG8 MWG9 MWG10 MWG11 MWL MWLD XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5
+  XP0_6 XP0_7 VDD VSS
** Bimod_Tag_ROMMWD: 104 flat devices **
d91 VSS MA1 NDIO12 0.2116P 1.84U
d92 VSS MA0 NDIO12 0.2116P 1.84U
m1 MWL WL0_EN_ VDD VDD P12 L=0.13U W=25.02U
m10 MBL MWG3 VSS VSS N12 L=0.13U W=0.4U
m100 WL0_EN_ N57 N142 VSS N12 L=0.13U W=3.78U
m101 N129 N75 VDD VDD P12 L=0.33U W=1.54U
m102 N129 N75 VSS VSS N12 L=0.33U W=1.4U
m103 N57 N129 VDD VDD P12 L=0.33U W=1.54U
m104 N57 N129 VSS VSS N12 L=0.33U W=1.4U
m11 MBL MWG4 VSS VSS N12 L=0.13U W=0.4U
m12 MBL MWG5 VSS VSS N12 L=0.13U W=0.4U
m13 MBL MWG6 VSS VSS N12 L=0.13U W=0.4U
m14 MBL MWG7 VSS VSS N12 L=0.13U W=0.4U
m15 MBL MWG8 VSS VSS N12 L=0.13U W=0.4U
m16 MBL MWG9 VSS VSS N12 L=0.13U W=0.4U
m17 MBL MWG10 VSS VSS N12 L=0.13U W=0.4U
m18 MBL MWG11 VSS VSS N12 L=0.13U W=0.4U
m19 N72 GTP VDD VDD P12 L=0.33U W=1.54U
m2 MWL WL0_EN_ VSS VSS N12 L=0.13U W=11.12U
m20 N72 GTP VSS VSS N12 L=0.33U W=1.4U
m21 N75 N72 VDD VDD P12 L=0.33U W=1.54U
m22 N75 N72 VSS VSS N12 L=0.33U W=1.4U
m23 N51 MA0 VDD VDD P12 L=0.13U W=0.3U
m24 N51 MA0 VSS VSS N12 L=0.13U W=0.3U
m25 N49 MA1 VDD VDD P12 L=0.13U W=0.3U
m26 N49 MA1 VSS VSS N12 L=0.13U W=0.3U
m27 N82 MA0 VDD VDD P12 L=0.13U W=0.3U
m28 N82 MA0 VSS VSS N12 L=0.13U W=0.3U
m29 N85 MA1 VDD VDD P12 L=0.13U W=0.3U
m3 MBL GTP VDD VDD P12 L=0.13U W=11.28U
m30 N85 MA1 VSS VSS N12 L=0.13U W=0.3U
m31 N50 N85 VDD VDD P12 L=0.13U W=0.3U
m32 N50 N85 VSS VSS N12 L=0.13U W=0.3U
m33 N52 N82 VDD VDD P12 L=0.13U W=0.3U
m34 N52 N82 VSS VSS N12 L=0.13U W=0.3U
m35 N58 N49 VDD VDD P12 L=0.13U W=0.3U
m36 N134 N49 VSS VSS N12 L=0.13U W=0.38U
m37 N58 N51 VDD VDD P12 L=0.13U W=0.3U
m38 N58 N51 N134 VSS N12 L=0.13U W=0.38U
m39 N59 N52 VDD VDD P12 L=0.13U W=0.3U
m4 MBL GTP VDD VDD P12 L=0.13U W=11.28U
m40 N135 N52 VSS VSS N12 L=0.13U W=0.38U
m41 N59 N49 VDD VDD P12 L=0.13U W=0.3U
m42 N59 N49 N135 VSS N12 L=0.13U W=0.38U
m43 N60 N50 VDD VDD P12 L=0.13U W=0.3U
m44 N136 N50 VSS VSS N12 L=0.13U W=0.38U
m45 N60 N51 VDD VDD P12 L=0.13U W=0.3U
m46 N60 N51 N136 VSS N12 L=0.13U W=0.38U
m47 N61 N50 VDD VDD P12 L=0.13U W=0.3U
m48 N137 N50 VSS VSS N12 L=0.13U W=0.38U
m49 N61 N52 VDD VDD P12 L=0.13U W=0.3U
m5 MBL MWLD VSS VSS N12 L=0.13U W=0.4U
m50 N61 N52 N137 VSS N12 L=0.13U W=0.38U
m51 N63 N57 VDD VDD P12 L=0.13U W=0.3U
m52 N138 N57 VSS VSS N12 L=0.13U W=0.38U
m53 N63 N55 VDD VDD P12 L=0.13U W=0.3U
m54 N63 N55 N138 VSS N12 L=0.13U W=0.38U
m55 N64 N57 VDD VDD P12 L=0.13U W=0.3U
m56 N139 N57 VSS VSS N12 L=0.13U W=0.38U
m57 N64 N54 VDD VDD P12 L=0.13U W=0.3U
m58 N64 N54 N139 VSS N12 L=0.13U W=0.38U
m59 N55 N64 VDD VDD P12 L=0.13U W=0.5U
m6 MBL MWLD VSS VSS N12 L=0.13U W=0.4U
m60 N55 N64 VSS VSS N12 L=0.13U W=0.5U
m61 N53 N63 VDD VDD P12 L=0.13U W=0.3U
m62 N53 N63 VSS VSS N12 L=0.13U W=0.3U
m63 N56 VSS N53 VDD P12 L=0.27U W=0.75U
m64 N56 N63 N53 VSS N12 L=0.27U W=0.75U
m65 N54 N65 N57 VDD P12 L=0.15U W=0.6U
m66 N54 N58 N57 VSS N12 L=0.15U W=0.6U
m67 N56 N61 N66 VDD P12 L=0.27U W=0.75U
m68 N56 N108 N66 VSS N12 L=0.27U W=0.75U
m69 N55 N60 N66 VDD P12 L=0.22U W=0.75U
m7 MBL MWG0 VSS VSS N12 L=0.13U W=0.4U
m70 N55 N109 N66 VSS N12 L=0.22U W=0.75U
m71 N54 N59 N66 VDD P12 L=0.15U W=0.6U
m72 N54 N110 N66 VSS N12 L=0.15U W=0.6U
m73 N57 N58 N62 VDD P12 L=0.24U W=0.5U
m74 N57 N111 N62 VSS N12 L=0.24U W=0.5U
m75 N67 N68 VDD VDD P12 L=0.13U W=1.5U
m76 N67 N68 VSS VSS N12 L=0.13U W=0.75U
m77 N109 N60 VDD VDD P12 L=0.13U W=0.5U
m78 N109 N60 VSS VSS N12 L=0.13U W=0.5U
m79 N108 N61 VDD VDD P12 L=0.13U W=0.3U
m8 MBL MWG1 VSS VSS N12 L=0.13U W=0.4U
m80 N108 N61 VSS VSS N12 L=0.13U W=0.3U
m81 N110 N59 VDD VDD P12 L=0.13U W=0.5U
m82 N110 N59 VSS VSS N12 L=0.13U W=0.5U
m83 N111 N58 VDD VDD P12 L=0.13U W=0.24U
m84 N111 N58 VSS VSS N12 L=0.13U W=0.15U
m85 N65 N58 VDD VDD P12 L=0.13U W=0.24U
m86 N65 N58 VSS VSS N12 L=0.13U W=0.15U
m87 N54 N65 VSS VSS N12 L=0.13U W=0.18U
m88 N66 N111 VSS VSS N12 L=0.13U W=0.18U
m89 N67 N111 N62 VDD P12 L=0.15U W=0.65U
m9 MBL MWG2 VSS VSS N12 L=0.13U W=0.4U
m90 N67 N58 N62 VSS N12 L=0.15U W=0.65U
m93 N68 N66 VSS VSS N12 L=0.15U W=0.5U
m94 VDD N66 N68 VDD P12 L=0.15U W=1U
m95 N143 N62 VSS VSS N12 L=0.13U W=3.78U
m96 WL0_EN_ N57 N143 VSS N12 L=0.13U W=3.78U
m97 WL0_EN_ N62 VDD VDD P12 L=0.13U W=6.82U
m98 N142 N62 VSS VSS N12 L=0.13U W=3.78U
m99 WL0_EN_ N57 VDD VDD P12 L=0.13U W=6.82U
.ENDS Bimod_Tag_ROMMWD
****
.SUBCKT Bimod_Tag_ROMMWDX GTP MBL MWL MWLD XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5
+  XP0_6 XP0_7 VDD VSS
** Bimod_Tag_ROMMWDX: 104 flat devices **
XI0 GTP VSS VSS MBL MWLD VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS MWL MWLD
+  XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP0_6 XP0_7 VDD VSS Bimod_Tag_ROMMWD
.ENDS Bimod_Tag_ROMMWDX
****
.SUBCKT Bimod_Tag_ROMWDSTACK GTP MBL MWL MWLD WL0_0 WL0_1 WL1_0 WL1_1 WL2_0
+  WL2_1 WL3_0 WL3_1 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP0_6 XP0_7 XPX_0
+  XPX_1 VDD VSS
** Bimod_Tag_ROMWDSTACK: 212 flat devices **
XI0 GTP WL0_0 WL1_0 WL2_0 WL3_0 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP0_6
+  XP0_7 XPX_0 XPX_1 VDD VSS Bimod_Tag_ROMWDXR0
XI1 GTP WL0_1 WL1_1 WL2_1 WL3_1 XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP0_6
+  XP0_7 XPX_0 XPX_1 VDD VSS Bimod_Tag_ROMWDXMX
XI2 GTP MBL MWL MWLD XP0_0 XP0_1 XP0_2 XP0_3 XP0_4 XP0_5 XP0_6 XP0_7 VDD VSS
+  Bimod_Tag_ROMMWDX
.ENDS Bimod_Tag_ROMWDSTACK
****
.SUBCKT Bimod_Tag_ROMHCKA CLK GSRCN GTP GTPN RST YP24_0 YP24_1 YP24_2 YP24_3
+  YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMHCKA: 9 flat devices **
m1 GTPN CLK N19 VSS N12 L=0.13U W=17.85U
m2 GTPN RST VDD VDD P12 L=0.13U W=27.84U
m3 GTP GTPN VDD VDD P12 L=0.13U W=75.12U
m4 GTP GTPN VSS VSS N12 L=0.13U W=38.52U
m5 CK-GTPNSRC GSRCN VDD VDD P12 L=0.13U W=6.54U
m6 CK-GTPNSRC GSRCN VSS VSS N12 L=0.13U W=4.6U
m7 N19 CLK CK-SRCFEED VSS N12 L=0.13U W=17.85U
m8 CK-SRCFEED CK-GTPNSRC VSS VSS N12 L=0.2U W=9U
m9 CK-SRCFEED CK-GTPNSRC VSS VSS N12 L=0.2U W=9U
.ENDS Bimod_Tag_ROMHCKA
****
.SUBCKT Bimod_Tag_ROMCK CLK GSRCN GTP GTPN RST YP24_0 YP24_1 YP24_2 YP24_3
+  YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMCK: 9 flat devices **
m1 GTPN CLK N19 VSS N12 L=0.13U W=17.85U
m2 GTPN RST VDD VDD P12 L=0.13U W=27.84U
m3 GTP GTPN VDD VDD P12 L=0.13U W=75.12U
m4 GTP GTPN VSS VSS N12 L=0.13U W=38.52U
m5 GTPNSRC GSRCN VDD VDD P12 L=0.13U W=6.54U
m6 GTPNSRC GSRCN VSS VSS N12 L=0.13U W=4.6U
m7 N19 CLK SRCFEED VSS N12 L=0.13U W=17.85U
m8 SRCFEED GTPNSRC VSS VSS N12 L=0.2U W=9U
m9 SRCFEED GTPNSRC VSS VSS N12 L=0.2U W=9U
.ENDS Bimod_Tag_ROMCK
****
.SUBCKT Bimod_Tag_ROMCLK_DRVS CLK GSRCN GTPN GTP_0 GTP_1 GTP_2 GTP_3 GTP_4 RST
+  YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5
+  YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMCLK_DRVS: 45 flat devices **
XI0 CLK GSRCN GTP_4 GTPN RST YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMHCKA
XI1 CLK GSRCN GTP_0 GTPN RST YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMCK
XI2 CLK GSRCN GTP_1 GTPN RST YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMCK
XI3 CLK GSRCN GTP_2 GTPN RST YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMCK
XI4 CLK GSRCN GTP_3 GTPN RST YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMCK
.ENDS Bimod_Tag_ROMCLK_DRVS
****
.SUBCKT Bimod_Tag_ROMSA16 DB GTP Q REFDB VDD VSS
** Bimod_Tag_ROMSA16: 50 flat devices **
d1 VSS Q NDIO12 0.2116P 1.84U
d50 VSS GTP NDIO12 0.2116P 1.84U
m10 GTPN GTP VSS VSS N12 L=0.13U W=0.35U
m11 ND1 GTPN VDD VDD P12 L=0.13U W=0.22U
m12 ND1 GTPN VSS VSS N12 L=0.13U W=0.16U
m13 ND2 ND1 VDD VDD P12 L=0.13U W=0.56U
m14 ND2 ND1 VSS VSS N12 L=0.13U W=0.66U
m15 N36 DBPRE VSS VSS N12 L=0.13U W=0.66U
m16 SPN GTPN N36 VSS N12 L=0.13U W=0.45U
m17 SPN DBPRE VDD VDD P12 L=0.13U W=0.48U
m18 SPN GTPN VDD VDD P12 L=0.13U W=0.29U
m19 DBPRE ND2 VDD VDD P12 L=0.13U W=2.92U
m2 N24 SRCD VSS VSS N12 L=0.13U W=1.69U
m20 DBPRE ND2 VSS VSS N12 L=0.13U W=1.66U
m21 REFDB DBPRE VDD VDD P12 L=0.13U W=3.22U
m22 DB DBPRE VDD VDD P12 L=0.13U W=3.22U
m23 DB DBPRE REFDB VDD P12 L=0.13U W=4.3U
m24 SD_ SD SRC VSS N12 L=0.19U W=4U
m25 SD SD_ SRC VSS N12 L=0.19U W=2.16U
m26 SD_ SD SRC VSS N12 L=0.19U W=4U
m27 SD SD_ SRC VSS N12 L=0.19U W=2.16U
m28 SRC GTPN N24 VSS N12 L=0.13U W=1.85U
m29 SRCD SRCPU VDD VDD P12 L=0.13U W=0.58U
m3 SD SP DB VDD P12 L=0.13U W=3.8U
m30 SRCD SRCPU VSS VSS N12 L=0.13U W=0.34U
m31 SRCPU DBPRE VDD VDD P12 L=0.13U W=0.66U
m32 SRCPU DBPRE VSS VSS N12 L=0.13U W=0.3U
m33 VDD SRCPU SRC VSS N12 L=0.13U W=1.86U
m34 SD SRCD SD_ VDD P12 L=0.13U W=0.42U
m35 SRC GTPN N48 VSS N12 L=0.13U W=1.85U
m36 N48 SRCD VSS VSS N12 L=0.13U W=1.69U
m37 SI SD VDD VDD P12 L=0.13U W=1.02U
m38 SI SD VSS VSS N12 L=0.13U W=0.5U
m39 SI_ SD_ VDD VDD P12 L=0.13U W=1.02U
m4 SD_ SP REFDB VDD P12 L=0.13U W=1.2U
m40 SI_ SD_ VSS VSS N12 L=0.13U W=0.5U
m41 SDB SI VSS VSS N12 L=0.13U W=1.1U
m42 SDB_ SI_ VSS VSS N12 L=0.13U W=1.1U
m43 SDB SDB_ VDD VDD P12 L=0.13U W=0.52U
m44 SDB SDB_ VSS VSS N12 L=0.13U W=0.3U
m45 SDB_ SDB VDD VDD P12 L=0.13U W=0.75U
m46 SDB_ SDB VSS VSS N12 L=0.13U W=0.3U
m47 Q SDB_ VDD VDD P12 L=0.13U W=4.34U
m48 Q SDB_ VSS VSS N12 L=0.13U W=2.52U
m49 SD_ VDD REFDB VDD P12 L=0.13U W=1.2U
m5 SD_ SD VDD VDD P12 L=0.13U W=0.42U
m6 SD SD_ VDD VDD P12 L=0.13U W=0.42U
m7 SP SPN VDD VDD P12 L=0.13U W=1.03U
m8 SP SPN VSS VSS N12 L=0.13U W=0.75U
m9 GTPN GTP VDD VDD P12 L=0.13U W=0.65U
.ENDS Bimod_Tag_ROMSA16
****
.SUBCKT Bimod_Tag_ROMSA_ROW DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9
+  DB_10 DB_11 DB_12 DB_13 DB_14 DB_15 GTP Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8
+  Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 REFDB_0 REFDB_1 REFDB_2 REFDB_3 REFDB_4
+  REFDB_5 REFDB_6 REFDB_7 REFDB_8 REFDB_9 REFDB_10 REFDB_11 REFDB_12 REFDB_13
+  REFDB_14 REFDB_15 VDD VSS
** Bimod_Tag_ROMSA_ROW: 800 flat devices **
XI0 DB_0 GTP Q_0 REFDB_0 VDD VSS Bimod_Tag_ROMSA16
XI1 DB_1 GTP Q_1 REFDB_1 VDD VSS Bimod_Tag_ROMSA16
XI10 DB_10 GTP Q_10 REFDB_10 VDD VSS Bimod_Tag_ROMSA16
XI11 DB_11 GTP Q_11 REFDB_11 VDD VSS Bimod_Tag_ROMSA16
XI12 DB_12 GTP Q_12 REFDB_12 VDD VSS Bimod_Tag_ROMSA16
XI13 DB_13 GTP Q_13 REFDB_13 VDD VSS Bimod_Tag_ROMSA16
XI14 DB_14 GTP Q_14 REFDB_14 VDD VSS Bimod_Tag_ROMSA16
XI15 DB_15 GTP Q_15 REFDB_15 VDD VSS Bimod_Tag_ROMSA16
XI2 DB_2 GTP Q_2 REFDB_2 VDD VSS Bimod_Tag_ROMSA16
XI3 DB_3 GTP Q_3 REFDB_3 VDD VSS Bimod_Tag_ROMSA16
XI4 DB_4 GTP Q_4 REFDB_4 VDD VSS Bimod_Tag_ROMSA16
XI5 DB_5 GTP Q_5 REFDB_5 VDD VSS Bimod_Tag_ROMSA16
XI6 DB_6 GTP Q_6 REFDB_6 VDD VSS Bimod_Tag_ROMSA16
XI7 DB_7 GTP Q_7 REFDB_7 VDD VSS Bimod_Tag_ROMSA16
XI8 DB_8 GTP Q_8 REFDB_8 VDD VSS Bimod_Tag_ROMSA16
XI9 DB_9 GTP Q_9 REFDB_9 VDD VSS Bimod_Tag_ROMSA16
.ENDS Bimod_Tag_ROMSA_ROW
****
.SUBCKT Bimod_Tag_ROMCDREF BLLREF BLRREF DBLB DBLT DBRB DBRT GTPCD REFDBL
+  REFDBR YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4
+  YP38_5 YP38_6 YP38_7 YREFB YREFT VDD VSS
** Bimod_Tag_ROMCDREF: 22 flat devices **
m1 GTPCD VSS N31 VDD P12 L=0.13U W=0.38U
m10 GTPCD VSS N33 VDD P12 L=0.13U W=0.38U
m11 N33 VDD GTPCD VSS N12 L=0.13U W=0.38U
m12 N34 YREFB VDD VDD P12 L=0.13U W=0.4U
m13 N34 YREFB VSS VSS N12 L=0.13U W=0.4U
m14 YREFB N33 VDD VDD P12 L=0.13U W=2.42U
m15 YREFB N33 VSS VSS N12 L=0.13U W=1.41U
m16 BLLREF N34 BLRREF VDD P12 L=0.13U W=4.7U
m17 BLLREF N34 VDD VDD P12 L=0.13U W=4.7U
m18 BLRREF N34 VDD VDD P12 L=0.13U W=4.7U
m19 BLLREF YREFB REFDBL VDD P12 L=0.13U W=3.76U
m2 N31 VDD GTPCD VSS N12 L=0.13U W=0.38U
m20 REFDBR YREFB BLRREF VDD P12 L=0.13U W=3.76U
m21 REFDBR VDD REFDBR VDD P12 L=0.13U W=22.56U
m22 REFDBL VDD REFDBL VDD P12 L=0.13U W=22.56U
m3 N32 YREFT VDD VDD P12 L=0.13U W=0.4U
m4 N32 YREFT VSS VSS N12 L=0.13U W=0.4U
m5 YREFT N31 VDD VDD P12 L=0.13U W=2.42U
m6 YREFT N31 VSS VSS N12 L=0.13U W=1.41U
m7 BLLREF N32 BLRREF VDD P12 L=0.13U W=4.7U
m8 BLLREF N32 VDD VDD P12 L=0.13U W=4.7U
m9 BLRREF N32 VDD VDD P12 L=0.13U W=4.7U
.ENDS Bimod_Tag_ROMCDREF
****
.SUBCKT Bimod_Tag_ROMHCD16 B0 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14
+  B15 BLEQE BLEQO DB DBREF GTPCD YP07LV0 YP07LV1 YP07RV0 YP07RV1 YP0123V0
+  YP0123V1 YP16LV0 YP16LV1 YP16RV0 YP16RV1 YP24_0 YP24_1 YP24_2 YP24_3
+  YP25LV0 YP25LV1 YP25RV0 YP25RV1 YP34LV0 YP34LV1 YP34RV0 YP34RV1 YP38_0
+  YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG04 YPG15 YPG26 YPG37
+  VDD VSS
** Bimod_Tag_ROMHCD16: 352 flat devices **
m1 B0 CD8_I0-PBL0 VDD VDD P12 L=0.13U W=9.4U
m10 N75 N77 VSS VSS N12 L=0.13U W=0.3U
m100 N91 N93 VSS VSS N12 L=0.13U W=0.3U
m101 N92 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m102 N214 YP0123V0 VSS VSS N12 L=0.13U W=0.31U
m103 N92 YP25RV0 VDD VDD P12 L=0.13U W=0.3U
m104 N92 YP25RV0 N214 VSS N12 L=0.13U W=0.31U
m105 N168 N92 VDD VDD P12 L=0.13U W=0.26U
m106 N168 N92 VSS VSS N12 L=0.13U W=0.15U
m107 N169 N93 VDD VDD P12 L=0.13U W=0.26U
m108 N169 N93 VSS VSS N12 L=0.13U W=0.15U
m109 N93 YP16RV0 VDD VDD P12 L=0.13U W=0.3U
m11 CD8_I0-PBL0 YPG04 VDD VDD P12 L=0.13U W=1.3U
m110 N215 YP16RV0 VSS VSS N12 L=0.13U W=0.31U
m111 N93 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m112 N93 YP0123V0 N215 VSS N12 L=0.13U W=0.31U
m113 B4 N178 B7 VDD P12 L=0.13U W=9.4U
m114 B7 N179 B8 VDD P12 L=0.13U W=9.42U
m115 B5 CD8_I0-PBL5 VDD VDD P12 L=0.13U W=9.4U
m116 DB N94 B5 VDD P12 L=0.13U W=3.76U
m117 B6 CD8_I0-PBL6 VDD VDD P12 L=0.13U W=9.4U
m118 DB N95 B6 VDD P12 L=0.13U W=3.76U
m119 CD8_I0-PBL5 N94 VDD VDD P12 L=0.13U W=1.3U
m12 CD8_I0-PBL0 YPG04 VSS VSS N12 L=0.13U W=0.94U
m120 CD8_I0-PBL5 N94 VSS VSS N12 L=0.13U W=0.94U
m121 N94 N90 VDD VDD P12 L=0.13U W=2.42U
m122 N94 N90 VSS VSS N12 L=0.13U W=1.42U
m123 CD8_I0-PBL6 N95 VDD VDD P12 L=0.13U W=1.3U
m124 CD8_I0-PBL6 N95 VSS VSS N12 L=0.13U W=0.94U
m125 N95 N91 VDD VDD P12 L=0.13U W=2.42U
m126 N95 N91 VSS VSS N12 L=0.13U W=1.42U
m127 B5 N190 B6 VDD P12 L=0.13U W=9.4U
m128 B6 N191 B9 VDD P12 L=0.13U W=9.42U
m129 N217 N78 VSS VSS N12 L=0.13U W=0.94U
m13 YPG04 N74 VDD VDD P12 L=0.13U W=2.42U
m130 N134 YPG04 N217 VSS N12 L=0.13U W=0.94U
m131 N134 N78 VDD VDD P12 L=0.13U W=1.29U
m132 N216 N78 VSS VSS N12 L=0.13U W=0.94U
m133 N134 YPG04 VDD VDD P12 L=0.13U W=1.29U
m134 N134 YPG04 N216 VSS N12 L=0.13U W=0.94U
m135 N219 N88 VSS VSS N12 L=0.13U W=0.94U
m136 N135 N78 N219 VSS N12 L=0.13U W=0.94U
m137 N135 N88 VDD VDD P12 L=0.13U W=1.29U
m138 N218 N88 VSS VSS N12 L=0.13U W=0.94U
m139 N135 N78 VDD VDD P12 L=0.13U W=1.29U
m14 YPG04 N74 VSS VSS N12 L=0.13U W=1.42U
m140 N135 N78 N218 VSS N12 L=0.13U W=0.94U
m141 N221 N89 VSS VSS N12 L=0.13U W=0.94U
m142 N178 N88 N221 VSS N12 L=0.13U W=0.94U
m143 N178 N89 VDD VDD P12 L=0.13U W=1.29U
m144 N220 N89 VSS VSS N12 L=0.13U W=0.94U
m145 N178 N88 VDD VDD P12 L=0.13U W=1.29U
m146 N178 N88 N220 VSS N12 L=0.13U W=0.94U
m147 N223 N57 VSS VSS N12 L=0.13U W=0.94U
m148 N179 N89 N223 VSS N12 L=0.13U W=0.94U
m149 N179 N57 VDD VDD P12 L=0.13U W=1.29U
m15 CD8_I0-PBL3 N78 VDD VDD P12 L=0.13U W=1.3U
m150 N222 N57 VSS VSS N12 L=0.13U W=0.94U
m151 N179 N89 VDD VDD P12 L=0.13U W=1.29U
m152 N179 N89 N222 VSS N12 L=0.13U W=0.94U
m153 N225 N83 VSS VSS N12 L=0.13U W=0.94U
m154 N146 YPG15 N225 VSS N12 L=0.13U W=0.94U
m155 N146 N83 VDD VDD P12 L=0.13U W=1.29U
m156 N224 N83 VSS VSS N12 L=0.13U W=0.94U
m157 N146 YPG15 VDD VDD P12 L=0.13U W=1.29U
m158 N146 YPG15 N224 VSS N12 L=0.13U W=0.94U
m159 N227 N94 VSS VSS N12 L=0.13U W=0.94U
m16 CD8_I0-PBL3 N78 VSS VSS N12 L=0.13U W=0.94U
m160 N147 N83 N227 VSS N12 L=0.13U W=0.94U
m161 N147 N94 VDD VDD P12 L=0.13U W=1.29U
m162 N226 N94 VSS VSS N12 L=0.13U W=0.94U
m163 N147 N83 VDD VDD P12 L=0.13U W=1.29U
m164 N147 N83 N226 VSS N12 L=0.13U W=0.94U
m165 N229 N95 VSS VSS N12 L=0.13U W=0.94U
m166 N190 N94 N229 VSS N12 L=0.13U W=0.94U
m167 N190 N95 VDD VDD P12 L=0.13U W=1.29U
m168 N228 N95 VSS VSS N12 L=0.13U W=0.94U
m169 N190 N94 VDD VDD P12 L=0.13U W=1.29U
m17 N78 N75 VDD VDD P12 L=0.13U W=2.42U
m170 N190 N94 N228 VSS N12 L=0.13U W=0.94U
m171 N231 N56 VSS VSS N12 L=0.13U W=0.94U
m172 N191 N95 N231 VSS N12 L=0.13U W=0.94U
m173 N191 N56 VDD VDD P12 L=0.13U W=1.29U
m174 N230 N56 VSS VSS N12 L=0.13U W=0.94U
m175 N191 N95 VDD VDD P12 L=0.13U W=1.29U
m176 N191 N95 N230 VSS N12 L=0.13U W=0.94U
m177 B8 CD8_I1-PBL0 VDD VDD P12 L=0.13U W=9.4U
m178 DB N57 B8 VDD P12 L=0.13U W=3.76U
m179 GTPCD N234 N232 VDD P12 L=0.13U W=0.38U
m18 N78 N75 VSS VSS N12 L=0.13U W=1.42U
m180 N232 N263 GTPCD VSS N12 L=0.13U W=0.38U
m181 B11 CD8_I1-PBL3 VDD VDD P12 L=0.13U W=9.4U
m182 DB N236 B11 VDD P12 L=0.13U W=3.76U
m183 GTPCD N235 N233 VDD P12 L=0.13U W=0.38U
m184 N233 N265 GTPCD VSS N12 L=0.13U W=0.38U
m185 N232 N234 VSS VSS N12 L=0.13U W=0.3U
m186 N233 N235 VSS VSS N12 L=0.13U W=0.3U
m187 CD8_I1-PBL0 N57 VDD VDD P12 L=0.13U W=1.3U
m188 CD8_I1-PBL0 N57 VSS VSS N12 L=0.13U W=0.94U
m189 N57 N232 VDD VDD P12 L=0.13U W=2.42U
m19 N76 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m190 N57 N232 VSS VSS N12 L=0.13U W=1.42U
m191 CD8_I1-PBL3 N236 VDD VDD P12 L=0.13U W=1.3U
m192 CD8_I1-PBL3 N236 VSS VSS N12 L=0.13U W=0.94U
m193 N236 N233 VDD VDD P12 L=0.13U W=2.42U
m194 N236 N233 VSS VSS N12 L=0.13U W=1.42U
m195 N234 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m196 N366 YP0123V1 VSS VSS N12 L=0.13U W=0.31U
m197 N234 YP07LV1 VDD VDD P12 L=0.13U W=0.3U
m198 N234 YP07LV1 N366 VSS N12 L=0.13U W=0.31U
m199 N263 N234 VDD VDD P12 L=0.13U W=0.26U
m2 DB YPG04 B0 VDD P12 L=0.13U W=3.76U
m20 N208 YP0123V0 VSS VSS N12 L=0.13U W=0.31U
m200 N263 N234 VSS VSS N12 L=0.13U W=0.15U
m201 N265 N235 VDD VDD P12 L=0.13U W=0.26U
m202 N265 N235 VSS VSS N12 L=0.13U W=0.15U
m203 N235 YP34LV1 VDD VDD P12 L=0.13U W=0.3U
m204 N367 YP34LV1 VSS VSS N12 L=0.13U W=0.31U
m205 N235 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m206 N235 YP0123V1 N367 VSS N12 L=0.13U W=0.31U
m207 GTPCD N239 N237 VDD P12 L=0.13U W=0.38U
m208 N237 N282 GTPCD VSS N12 L=0.13U W=0.38U
m209 GTPCD N240 N238 VDD P12 L=0.13U W=0.38U
m21 N76 YP07LV0 VDD VDD P12 L=0.13U W=0.3U
m210 N238 N283 GTPCD VSS N12 L=0.13U W=0.38U
m211 N237 N239 VSS VSS N12 L=0.13U W=0.3U
m212 N238 N240 VSS VSS N12 L=0.13U W=0.3U
m213 N239 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m214 N368 YP0123V1 VSS VSS N12 L=0.13U W=0.31U
m215 N239 YP16LV1 VDD VDD P12 L=0.13U W=0.3U
m216 N239 YP16LV1 N368 VSS N12 L=0.13U W=0.31U
m217 N282 N239 VDD VDD P12 L=0.13U W=0.26U
m218 N282 N239 VSS VSS N12 L=0.13U W=0.15U
m219 N283 N240 VDD VDD P12 L=0.13U W=0.26U
m22 N76 YP07LV0 N208 VSS N12 L=0.13U W=0.31U
m220 N283 N240 VSS VSS N12 L=0.13U W=0.15U
m221 N240 YP25LV1 VDD VDD P12 L=0.13U W=0.3U
m222 N369 YP25LV1 VSS VSS N12 L=0.13U W=0.31U
m223 N240 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m224 N240 YP0123V1 N369 VSS N12 L=0.13U W=0.31U
m225 B8 N292 B11 VDD P12 L=0.13U W=9.4U
m226 B11 N293 B12 VDD P12 L=0.13U W=9.42U
m227 B9 CD8_I1-PBL1 VDD VDD P12 L=0.13U W=9.4U
m228 DB N56 B9 VDD P12 L=0.13U W=3.76U
m229 B10 CD8_I1-PBL2 VDD VDD P12 L=0.13U W=9.4U
m23 N105 N76 VDD VDD P12 L=0.13U W=0.26U
m230 DB N241 B10 VDD P12 L=0.13U W=3.76U
m231 CD8_I1-PBL1 N56 VDD VDD P12 L=0.13U W=1.3U
m232 CD8_I1-PBL1 N56 VSS VSS N12 L=0.13U W=0.94U
m233 N56 N237 VDD VDD P12 L=0.13U W=2.42U
m234 N56 N237 VSS VSS N12 L=0.13U W=1.42U
m235 CD8_I1-PBL2 N241 VDD VDD P12 L=0.13U W=1.3U
m236 CD8_I1-PBL2 N241 VSS VSS N12 L=0.13U W=0.94U
m237 N241 N238 VDD VDD P12 L=0.13U W=2.42U
m238 N241 N238 VSS VSS N12 L=0.13U W=1.42U
m239 B9 N304 B10 VDD P12 L=0.13U W=9.4U
m24 N105 N76 VSS VSS N12 L=0.13U W=0.15U
m240 B10 N305 B13 VDD P12 L=0.13U W=9.42U
m241 B12 CD8_I1-PBL4 VDD VDD P12 L=0.13U W=9.4U
m242 DB N246 B12 VDD P12 L=0.13U W=3.76U
m243 GTPCD N244 N242 VDD P12 L=0.13U W=0.38U
m244 N242 N307 GTPCD VSS N12 L=0.13U W=0.38U
m245 B15 CD8_I1-PBL7 VDD VDD P12 L=0.13U W=9.4U
m246 DB N247 B15 VDD P12 L=0.13U W=3.76U
m247 GTPCD N245 N243 VDD P12 L=0.13U W=0.38U
m248 N243 N309 GTPCD VSS N12 L=0.13U W=0.38U
m249 N242 N244 VSS VSS N12 L=0.13U W=0.3U
m25 N107 N77 VDD VDD P12 L=0.13U W=0.26U
m250 N243 N245 VSS VSS N12 L=0.13U W=0.3U
m251 CD8_I1-PBL4 N246 VDD VDD P12 L=0.13U W=1.3U
m252 CD8_I1-PBL4 N246 VSS VSS N12 L=0.13U W=0.94U
m253 N246 N242 VDD VDD P12 L=0.13U W=2.42U
m254 N246 N242 VSS VSS N12 L=0.13U W=1.42U
m255 CD8_I1-PBL7 N247 VDD VDD P12 L=0.13U W=1.3U
m256 CD8_I1-PBL7 N247 VSS VSS N12 L=0.13U W=0.94U
m257 N247 N243 VDD VDD P12 L=0.13U W=2.42U
m258 N247 N243 VSS VSS N12 L=0.13U W=1.42U
m259 N244 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m26 N107 N77 VSS VSS N12 L=0.13U W=0.15U
m260 N370 YP0123V1 VSS VSS N12 L=0.13U W=0.31U
m261 N244 YP34RV1 VDD VDD P12 L=0.13U W=0.3U
m262 N244 YP34RV1 N370 VSS N12 L=0.13U W=0.31U
m263 N307 N244 VDD VDD P12 L=0.13U W=0.26U
m264 N307 N244 VSS VSS N12 L=0.13U W=0.15U
m265 N309 N245 VDD VDD P12 L=0.13U W=0.26U
m266 N309 N245 VSS VSS N12 L=0.13U W=0.15U
m267 N245 YP07RV1 VDD VDD P12 L=0.13U W=0.3U
m268 N371 YP07RV1 VSS VSS N12 L=0.13U W=0.31U
m269 N245 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m27 N77 YP34LV0 VDD VDD P12 L=0.13U W=0.3U
m270 N245 YP0123V1 N371 VSS N12 L=0.13U W=0.31U
m271 GTPCD N250 N248 VDD P12 L=0.13U W=0.38U
m272 N248 N326 GTPCD VSS N12 L=0.13U W=0.38U
m273 GTPCD N251 N249 VDD P12 L=0.13U W=0.38U
m274 N249 N327 GTPCD VSS N12 L=0.13U W=0.38U
m275 N248 N250 VSS VSS N12 L=0.13U W=0.3U
m276 N249 N251 VSS VSS N12 L=0.13U W=0.3U
m277 N250 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m278 N372 YP0123V1 VSS VSS N12 L=0.13U W=0.31U
m279 N250 YP25RV1 VDD VDD P12 L=0.13U W=0.3U
m28 N209 YP34LV0 VSS VSS N12 L=0.13U W=0.31U
m280 N250 YP25RV1 N372 VSS N12 L=0.13U W=0.31U
m281 N326 N250 VDD VDD P12 L=0.13U W=0.26U
m282 N326 N250 VSS VSS N12 L=0.13U W=0.15U
m283 N327 N251 VDD VDD P12 L=0.13U W=0.26U
m284 N327 N251 VSS VSS N12 L=0.13U W=0.15U
m285 N251 YP16RV1 VDD VDD P12 L=0.13U W=0.3U
m286 N373 YP16RV1 VSS VSS N12 L=0.13U W=0.31U
m287 N251 YP0123V1 VDD VDD P12 L=0.13U W=0.3U
m288 N251 YP0123V1 N373 VSS N12 L=0.13U W=0.31U
m289 B12 N336 B15 VDD P12 L=0.13U W=9.4U
m29 N77 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m290 B15 N337 BLEQE VDD P12 L=0.13U W=9.42U
m291 B13 CD8_I1-PBL5 VDD VDD P12 L=0.13U W=9.4U
m292 DB N252 B13 VDD P12 L=0.13U W=3.76U
m293 B14 CD8_I1-PBL6 VDD VDD P12 L=0.13U W=9.4U
m294 DB N253 B14 VDD P12 L=0.13U W=3.76U
m295 CD8_I1-PBL5 N252 VDD VDD P12 L=0.13U W=1.3U
m296 CD8_I1-PBL5 N252 VSS VSS N12 L=0.13U W=0.94U
m297 N252 N248 VDD VDD P12 L=0.13U W=2.42U
m298 N252 N248 VSS VSS N12 L=0.13U W=1.42U
m299 CD8_I1-PBL6 N253 VDD VDD P12 L=0.13U W=1.3U
m3 GTPCD N76 N74 VDD P12 L=0.13U W=0.38U
m30 N77 YP0123V0 N209 VSS N12 L=0.13U W=0.31U
m300 CD8_I1-PBL6 N253 VSS VSS N12 L=0.13U W=0.94U
m301 N253 N249 VDD VDD P12 L=0.13U W=2.42U
m302 N253 N249 VSS VSS N12 L=0.13U W=1.42U
m303 B13 N348 B14 VDD P12 L=0.13U W=9.4U
m304 B14 N349 BLEQO VDD P12 L=0.13U W=9.42U
m305 N375 N236 VSS VSS N12 L=0.13U W=0.94U
m306 N292 N57 N375 VSS N12 L=0.13U W=0.94U
m307 N292 N236 VDD VDD P12 L=0.13U W=1.29U
m308 N374 N236 VSS VSS N12 L=0.13U W=0.94U
m309 N292 N57 VDD VDD P12 L=0.13U W=1.29U
m31 GTPCD N81 N79 VDD P12 L=0.13U W=0.38U
m310 N292 N57 N374 VSS N12 L=0.13U W=0.94U
m311 N377 N246 VSS VSS N12 L=0.13U W=0.94U
m312 N293 N236 N377 VSS N12 L=0.13U W=0.94U
m313 N293 N246 VDD VDD P12 L=0.13U W=1.29U
m314 N376 N246 VSS VSS N12 L=0.13U W=0.94U
m315 N293 N236 VDD VDD P12 L=0.13U W=1.29U
m316 N293 N236 N376 VSS N12 L=0.13U W=0.94U
m317 N379 N247 VSS VSS N12 L=0.13U W=0.94U
m318 N336 N246 N379 VSS N12 L=0.13U W=0.94U
m319 N336 N247 VDD VDD P12 L=0.13U W=1.29U
m32 N79 N124 GTPCD VSS N12 L=0.13U W=0.38U
m320 N378 N247 VSS VSS N12 L=0.13U W=0.94U
m321 N336 N246 VDD VDD P12 L=0.13U W=1.29U
m322 N336 N246 N378 VSS N12 L=0.13U W=0.94U
m323 N381 YPG26 VSS VSS N12 L=0.13U W=0.94U
m324 N337 N247 N381 VSS N12 L=0.13U W=0.94U
m325 N337 YPG26 VDD VDD P12 L=0.13U W=1.29U
m326 N380 YPG26 VSS VSS N12 L=0.13U W=0.94U
m327 N337 N247 VDD VDD P12 L=0.13U W=1.29U
m328 N337 N247 N380 VSS N12 L=0.13U W=0.94U
m329 N383 N241 VSS VSS N12 L=0.13U W=0.94U
m33 GTPCD N82 N80 VDD P12 L=0.13U W=0.38U
m330 N304 N56 N383 VSS N12 L=0.13U W=0.94U
m331 N304 N241 VDD VDD P12 L=0.13U W=1.29U
m332 N382 N241 VSS VSS N12 L=0.13U W=0.94U
m333 N304 N56 VDD VDD P12 L=0.13U W=1.29U
m334 N304 N56 N382 VSS N12 L=0.13U W=0.94U
m335 N385 N252 VSS VSS N12 L=0.13U W=0.94U
m336 N305 N241 N385 VSS N12 L=0.13U W=0.94U
m337 N305 N252 VDD VDD P12 L=0.13U W=1.29U
m338 N384 N252 VSS VSS N12 L=0.13U W=0.94U
m339 N305 N241 VDD VDD P12 L=0.13U W=1.29U
m34 N80 N125 GTPCD VSS N12 L=0.13U W=0.38U
m340 N305 N241 N384 VSS N12 L=0.13U W=0.94U
m341 N387 N253 VSS VSS N12 L=0.13U W=0.94U
m342 N348 N252 N387 VSS N12 L=0.13U W=0.94U
m343 N348 N253 VDD VDD P12 L=0.13U W=1.29U
m344 N386 N253 VSS VSS N12 L=0.13U W=0.94U
m345 N348 N252 VDD VDD P12 L=0.13U W=1.29U
m346 N348 N252 N386 VSS N12 L=0.13U W=0.94U
m347 N389 YPG37 VSS VSS N12 L=0.13U W=0.94U
m348 N349 N253 N389 VSS N12 L=0.13U W=0.94U
m349 N349 YPG37 VDD VDD P12 L=0.13U W=1.29U
m35 N79 N81 VSS VSS N12 L=0.13U W=0.3U
m350 N388 YPG37 VSS VSS N12 L=0.13U W=0.94U
m351 N349 N253 VDD VDD P12 L=0.13U W=1.29U
m352 N349 N253 N388 VSS N12 L=0.13U W=0.94U
m36 N80 N82 VSS VSS N12 L=0.13U W=0.3U
m37 N81 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m38 N210 YP0123V0 VSS VSS N12 L=0.13U W=0.31U
m39 N81 YP16LV0 VDD VDD P12 L=0.13U W=0.3U
m4 N74 N105 GTPCD VSS N12 L=0.13U W=0.38U
m40 N81 YP16LV0 N210 VSS N12 L=0.13U W=0.31U
m41 N124 N81 VDD VDD P12 L=0.13U W=0.26U
m42 N124 N81 VSS VSS N12 L=0.13U W=0.15U
m43 N125 N82 VDD VDD P12 L=0.13U W=0.26U
m44 N125 N82 VSS VSS N12 L=0.13U W=0.15U
m45 N82 YP25LV0 VDD VDD P12 L=0.13U W=0.3U
m46 N211 YP25LV0 VSS VSS N12 L=0.13U W=0.31U
m47 N82 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m48 N82 YP0123V0 N211 VSS N12 L=0.13U W=0.31U
m49 B0 N134 B3 VDD P12 L=0.13U W=9.4U
m5 B3 CD8_I0-PBL3 VDD VDD P12 L=0.13U W=9.4U
m50 B3 N135 B4 VDD P12 L=0.13U W=9.42U
m51 B1 CD8_I0-PBL1 VDD VDD P12 L=0.13U W=9.4U
m52 DB YPG15 B1 VDD P12 L=0.13U W=3.76U
m53 B2 CD8_I0-PBL2 VDD VDD P12 L=0.13U W=9.4U
m54 DB N83 B2 VDD P12 L=0.13U W=3.76U
m55 CD8_I0-PBL1 YPG15 VDD VDD P12 L=0.13U W=1.3U
m56 CD8_I0-PBL1 YPG15 VSS VSS N12 L=0.13U W=0.94U
m57 YPG15 N79 VDD VDD P12 L=0.13U W=2.42U
m58 YPG15 N79 VSS VSS N12 L=0.13U W=1.42U
m59 CD8_I0-PBL2 N83 VDD VDD P12 L=0.13U W=1.3U
m6 DB N78 B3 VDD P12 L=0.13U W=3.76U
m60 CD8_I0-PBL2 N83 VSS VSS N12 L=0.13U W=0.94U
m61 N83 N80 VDD VDD P12 L=0.13U W=2.42U
m62 N83 N80 VSS VSS N12 L=0.13U W=1.42U
m63 B1 N146 B2 VDD P12 L=0.13U W=9.4U
m64 B2 N147 B5 VDD P12 L=0.13U W=9.42U
m65 B4 CD8_I0-PBL4 VDD VDD P12 L=0.13U W=9.4U
m66 DB N88 B4 VDD P12 L=0.13U W=3.76U
m67 GTPCD N86 N84 VDD P12 L=0.13U W=0.38U
m68 N84 N149 GTPCD VSS N12 L=0.13U W=0.38U
m69 B7 CD8_I0-PBL7 VDD VDD P12 L=0.13U W=9.4U
m7 GTPCD N77 N75 VDD P12 L=0.13U W=0.38U
m70 DB N89 B7 VDD P12 L=0.13U W=3.76U
m71 GTPCD N87 N85 VDD P12 L=0.13U W=0.38U
m72 N85 N151 GTPCD VSS N12 L=0.13U W=0.38U
m73 N84 N86 VSS VSS N12 L=0.13U W=0.3U
m74 N85 N87 VSS VSS N12 L=0.13U W=0.3U
m75 CD8_I0-PBL4 N88 VDD VDD P12 L=0.13U W=1.3U
m76 CD8_I0-PBL4 N88 VSS VSS N12 L=0.13U W=0.94U
m77 N88 N84 VDD VDD P12 L=0.13U W=2.42U
m78 N88 N84 VSS VSS N12 L=0.13U W=1.42U
m79 CD8_I0-PBL7 N89 VDD VDD P12 L=0.13U W=1.3U
m8 N75 N107 GTPCD VSS N12 L=0.13U W=0.38U
m80 CD8_I0-PBL7 N89 VSS VSS N12 L=0.13U W=0.94U
m81 N89 N85 VDD VDD P12 L=0.13U W=2.42U
m82 N89 N85 VSS VSS N12 L=0.13U W=1.42U
m83 N86 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m84 N212 YP0123V0 VSS VSS N12 L=0.13U W=0.31U
m85 N86 YP34RV0 VDD VDD P12 L=0.13U W=0.3U
m86 N86 YP34RV0 N212 VSS N12 L=0.13U W=0.31U
m87 N149 N86 VDD VDD P12 L=0.13U W=0.26U
m88 N149 N86 VSS VSS N12 L=0.13U W=0.15U
m89 N151 N87 VDD VDD P12 L=0.13U W=0.26U
m9 N74 N76 VSS VSS N12 L=0.13U W=0.3U
m90 N151 N87 VSS VSS N12 L=0.13U W=0.15U
m91 N87 YP07RV0 VDD VDD P12 L=0.13U W=0.3U
m92 N213 YP07RV0 VSS VSS N12 L=0.13U W=0.31U
m93 N87 YP0123V0 VDD VDD P12 L=0.13U W=0.3U
m94 N87 YP0123V0 N213 VSS N12 L=0.13U W=0.31U
m95 GTPCD N92 N90 VDD P12 L=0.13U W=0.38U
m96 N90 N168 GTPCD VSS N12 L=0.13U W=0.38U
m97 GTPCD N93 N91 VDD P12 L=0.13U W=0.38U
m98 N91 N169 GTPCD VSS N12 L=0.13U W=0.38U
m99 N90 N92 VSS VSS N12 L=0.13U W=0.3U
.ENDS Bimod_Tag_ROMHCD16
****
.SUBCKT Bimod_Tag_ROMMUX_CD_O B0 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13
+  B14 B15 BLEQE BLEQO DB DBREF GTPCD YP24_0 YP24_1 YP24_2 YP24_3 YP38_0
+  YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26 YPG37 VDD VSS
** Bimod_Tag_ROMMUX_CD_O: 352 flat devices **
XI0 B0 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 BLEQE BLEQO DB DBREF
+  GTPCD YP38_7 YP38_7 YP38_0 YP38_0 YP24_1 YP24_0 YP38_6 YP38_6 YP38_1 YP38_1
+  YP24_0 YP24_1 YP24_2 YP24_3 YP38_5 YP38_5 YP38_2 YP38_2 YP38_4 YP38_4
+  YP38_3 YP38_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG04
+  YPG15 YPG26 YPG37 VDD VSS Bimod_Tag_ROMHCD16
.ENDS Bimod_Tag_ROMMUX_CD_O
****
.SUBCKT Bimod_Tag_ROMMUX_CD_E B0 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13
+  B14 B15 BLEQE BLEQO DB DBREF GTPCD YP24_0 YP24_1 YP24_2 YP24_3 YP38_0
+  YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26 YPG37 VDD VSS
** Bimod_Tag_ROMMUX_CD_E: 352 flat devices **
XI0 B0 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 BLEQE BLEQO DB DBREF
+  GTPCD YP38_0 YP38_0 YP38_7 YP38_7 YP24_0 YP24_1 YP38_1 YP38_1 YP38_6 YP38_6
+  YP24_0 YP24_1 YP24_2 YP24_3 YP38_2 YP38_2 YP38_5 YP38_5 YP38_3 YP38_3
+  YP38_4 YP38_4 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG04
+  YPG15 YPG26 YPG37 VDD VSS Bimod_Tag_ROMHCD16
.ENDS Bimod_Tag_ROMMUX_CD_E
****
.SUBCKT Bimod_Tag_ROMCD_ROW B0_0 B0_1 B0_2 B0_3 B0_4 B0_5 B0_6 B0_7 B0_8 B0_9
+  B0_10 B0_11 B0_12 B0_13 B0_14 B0_15 B1_0 B1_1 B1_2 B1_3 B1_4 B1_5 B1_6 B1_7
+  B1_8 B1_9 B1_10 B1_11 B1_12 B1_13 B1_14 B1_15 B2_0 B2_1 B2_2 B2_3 B2_4 B2_5
+  B2_6 B2_7 B2_8 B2_9 B2_10 B2_11 B2_12 B2_13 B2_14 B2_15 B3_0 B3_1 B3_2 B3_3
+  B3_4 B3_5 B3_6 B3_7 B3_8 B3_9 B3_10 B3_11 B3_12 B3_13 B3_14 B3_15 B4_0 B4_1
+  B4_2 B4_3 B4_4 B4_5 B4_6 B4_7 B4_8 B4_9 B4_10 B4_11 B4_12 B4_13 B4_14 B4_15
+  B5_0 B5_1 B5_2 B5_3 B5_4 B5_5 B5_6 B5_7 B5_8 B5_9 B5_10 B5_11 B5_12 B5_13
+  B5_14 B5_15 B6_0 B6_1 B6_2 B6_3 B6_4 B6_5 B6_6 B6_7 B6_8 B6_9 B6_10 B6_11
+  B6_12 B6_13 B6_14 B6_15 B7_0 B7_1 B7_2 B7_3 B7_4 B7_5 B7_6 B7_7 B7_8 B7_9
+  B7_10 B7_11 B7_12 B7_13 B7_14 B7_15 B8_0 B8_1 B8_2 B8_3 B8_4 B8_5 B8_6 B8_7
+  B8_8 B8_9 B8_10 B8_11 B8_12 B8_13 B8_14 B8_15 B9_0 B9_1 B9_2 B9_3 B9_4 B9_5
+  B9_6 B9_7 B9_8 B9_9 B9_10 B9_11 B9_12 B9_13 B9_14 B9_15 B10_0 B10_1 B10_2
+  B10_3 B10_4 B10_5 B10_6 B10_7 B10_8 B10_9 B10_10 B10_11 B10_12 B10_13
+  B10_14 B10_15 B11_0 B11_1 B11_2 B11_3 B11_4 B11_5 B11_6 B11_7 B11_8 B11_9
+  B11_10 B11_11 B11_12 B11_13 B11_14 B11_15 B12_0 B12_1 B12_2 B12_3 B12_4
+  B12_5 B12_6 B12_7 B12_8 B12_9 B12_10 B12_11 B12_12 B12_13 B12_14 B12_15
+  B13_0 B13_1 B13_2 B13_3 B13_4 B13_5 B13_6 B13_7 B13_8 B13_9 B13_10 B13_11
+  B13_12 B13_13 B13_14 B13_15 B14_0 B14_1 B14_2 B14_3 B14_4 B14_5 B14_6 B14_7
+  B14_8 B14_9 B14_10 B14_11 B14_12 B14_13 B14_14 B14_15 B15_0 B15_1 B15_2
+  B15_3 B15_4 B15_5 B15_6 B15_7 B15_8 B15_9 B15_10 B15_11 B15_12 B15_13
+  B15_14 B15_15 BLLREF_0 BLLREF_1 BLLREF_2 BLLREF_3 BLLREF_4 BLLREF_5
+  BLLREF_6 BLLREF_7 BLRREF_0 BLRREF_1 BLRREF_2 BLRREF_3 BLRREF_4 BLRREF_5
+  BLRREF_6 BLRREF_7 DBREF_0 DBREF_1 DBREF_2 DBREF_3 DBREF_4 DBREF_5 DBREF_6
+  DBREF_7 DBREF_8 DBREF_9 DBREF_10 DBREF_11 DBREF_12 DBREF_13 DBREF_14
+  DBREF_15 DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11
+  DB_12 DB_13 DB_14 DB_15 GTPCD YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1
+  YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMCD_ROW: 5808 flat devices **
XI0 B0_0 B1_0 B2_0 B3_0 B4_0 B5_0 B6_0 B7_0 B8_0 B9_0 B10_0 B11_0 B12_0 B13_0
+  B14_0 B15_0 BLLREF_0 BLLREF_0 DB_0 DBREF_0 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26_20
+  YPG37_22 VDD VSS Bimod_Tag_ROMMUX_CD_E
XI1 BLLREF_0 BLRREF_0 DB_0 DB_0 DB_1 DB_1 GTPCD DBREF_0 DBREF_1 YP24_0 YP24_1
+  YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7
+  YPG37_22 YPG26_20 VDD VSS Bimod_Tag_ROMCDREF
XI10 BLLREF_3 BLRREF_3 DB_6 DB_6 DB_7 DB_7 GTPCD DBREF_6 DBREF_7 YP24_0 YP24_1
+  YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG37
+  YPG26 VDD VSS Bimod_Tag_ROMCDREF
XI11 B0_7 B1_7 B2_7 B3_7 B4_7 B5_7 B6_7 B7_7 B8_7 B9_7 B10_7 B11_7 B12_7 B13_7
+  B14_7 B15_7 BLRREF_3 BLRREF_3 DB_7 DBREF_7 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26 YPG37
+  VDD VSS Bimod_Tag_ROMMUX_CD_O
XI12 B0_8 B1_8 B2_8 B3_8 B4_8 B5_8 B6_8 B7_8 B8_8 B9_8 B10_8 B11_8 B12_8 B13_8
+  B14_8 B15_8 BLLREF_4 BLLREF_4 DB_8 DBREF_8 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26_12
+  YPG37_14 VDD VSS Bimod_Tag_ROMMUX_CD_E
XI13 BLLREF_4 BLRREF_4 DB_8 DB_8 DB_9 DB_9 GTPCD DBREF_8 DBREF_9 YP24_0 YP24_1
+  YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7
+  YPG37_14 YPG26_12 VDD VSS Bimod_Tag_ROMCDREF
XI14 B0_9 B1_9 B2_9 B3_9 B4_9 B5_9 B6_9 B7_9 B8_9 B9_9 B10_9 B11_9 B12_9 B13_9
+  B14_9 B15_9 BLRREF_4 BLRREF_4 DB_9 DBREF_9 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26_12
+  YPG37_14 VDD VSS Bimod_Tag_ROMMUX_CD_O
XI15 B0_10 B1_10 B2_10 B3_10 B4_10 B5_10 B6_10 B7_10 B8_10 B9_10 B10_10 B11_10
+  B12_10 B13_10 B14_10 B15_10 BLLREF_5 BLLREF_5 DB_10 DBREF_10 GTPCD YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG26_16 YPG37_18 VDD VSS Bimod_Tag_ROMMUX_CD_E
XI16 BLLREF_5 BLRREF_5 DB_10 DB_10 DB_11 DB_11 GTPCD DBREF_10 DBREF_11 YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG37_18 YPG26_16 VDD VSS Bimod_Tag_ROMCDREF
XI17 B0_11 B1_11 B2_11 B3_11 B4_11 B5_11 B6_11 B7_11 B8_11 B9_11 B10_11 B11_11
+  B12_11 B13_11 B14_11 B15_11 BLRREF_5 BLRREF_5 DB_11 DBREF_11 GTPCD YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG26_16 YPG37_18 VDD VSS Bimod_Tag_ROMMUX_CD_O
XI18 B0_12 B1_12 B2_12 B3_12 B4_12 B5_12 B6_12 B7_12 B8_12 B9_12 B10_12 B11_12
+  B12_12 B13_12 B14_12 B15_12 BLLREF_6 BLLREF_6 DB_12 DBREF_12 GTPCD YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG26_4 YPG37_6 VDD VSS Bimod_Tag_ROMMUX_CD_E
XI19 BLLREF_6 BLRREF_6 DB_12 DB_12 DB_13 DB_13 GTPCD DBREF_12 DBREF_13 YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG37_6 YPG26_4 VDD VSS Bimod_Tag_ROMCDREF
XI2 B0_1 B1_1 B2_1 B3_1 B4_1 B5_1 B6_1 B7_1 B8_1 B9_1 B10_1 B11_1 B12_1 B13_1
+  B14_1 B15_1 BLRREF_0 BLRREF_0 DB_1 DBREF_1 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26_20
+  YPG37_22 VDD VSS Bimod_Tag_ROMMUX_CD_O
XI20 B0_13 B1_13 B2_13 B3_13 B4_13 B5_13 B6_13 B7_13 B8_13 B9_13 B10_13 B11_13
+  B12_13 B13_13 B14_13 B15_13 BLRREF_6 BLRREF_6 DB_13 DBREF_13 GTPCD YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG26_4 YPG37_6 VDD VSS Bimod_Tag_ROMMUX_CD_O
XI21 B0_14 B1_14 B2_14 B3_14 B4_14 B5_14 B6_14 B7_14 B8_14 B9_14 B10_14 B11_14
+  B12_14 B13_14 B14_14 B15_14 BLLREF_7 BLLREF_7 DB_14 DBREF_14 GTPCD YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG26_8 YPG37_10 VDD VSS Bimod_Tag_ROMMUX_CD_E
XI22 BLLREF_7 BLRREF_7 DB_14 DB_14 DB_15 DB_15 GTPCD DBREF_14 DBREF_15 YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG37_10 YPG26_8 VDD VSS Bimod_Tag_ROMCDREF
XI23 B0_15 B1_15 B2_15 B3_15 B4_15 B5_15 B6_15 B7_15 B8_15 B9_15 B10_15 B11_15
+  B12_15 B13_15 B14_15 B15_15 BLRREF_7 BLRREF_7 DB_15 DBREF_15 GTPCD YP24_0
+  YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 YPG26_8 YPG37_10 VDD VSS Bimod_Tag_ROMMUX_CD_O
XI3 B0_2 B1_2 B2_2 B3_2 B4_2 B5_2 B6_2 B7_2 B8_2 B9_2 B10_2 B11_2 B12_2 B13_2
+  B14_2 B15_2 BLLREF_1 BLLREF_1 DB_2 DBREF_2 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26_24
+  YPG37_26 VDD VSS Bimod_Tag_ROMMUX_CD_E
XI4 BLLREF_1 BLRREF_1 DB_2 DB_2 DB_3 DB_3 GTPCD DBREF_2 DBREF_3 YP24_0 YP24_1
+  YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7
+  YPG37_26 YPG26_24 VDD VSS Bimod_Tag_ROMCDREF
XI5 B0_3 B1_3 B2_3 B3_3 B4_3 B5_3 B6_3 B7_3 B8_3 B9_3 B10_3 B11_3 B12_3 B13_3
+  B14_3 B15_3 BLRREF_1 BLRREF_1 DB_3 DBREF_3 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26_24
+  YPG37_26 VDD VSS Bimod_Tag_ROMMUX_CD_O
XI6 B0_4 B1_4 B2_4 B3_4 B4_4 B5_4 B6_4 B7_4 B8_4 B9_4 B10_4 B11_4 B12_4 B13_4
+  B14_4 B15_4 BLLREF_2 BLLREF_2 DB_4 DBREF_4 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YREFT YREFB
+  VDD VSS Bimod_Tag_ROMMUX_CD_E
XI7 BLLREF_2 BLRREF_2 DB_4 DB_4 DB_5 DB_5 GTPCD DBREF_4 DBREF_5 YP24_0 YP24_1
+  YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YREFB
+  YREFT VDD VSS Bimod_Tag_ROMCDREF
XI8 B0_5 B1_5 B2_5 B3_5 B4_5 B5_5 B6_5 B7_5 B8_5 B9_5 B10_5 B11_5 B12_5 B13_5
+  B14_5 B15_5 BLRREF_2 BLRREF_2 DB_5 DBREF_5 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YREFT YREFB
+  VDD VSS Bimod_Tag_ROMMUX_CD_O
XI9 B0_6 B1_6 B2_6 B3_6 B4_6 B5_6 B6_6 B7_6 B8_6 B9_6 B10_6 B11_6 B12_6 B13_6
+  B14_6 B15_6 BLLREF_3 BLLREF_3 DB_6 DBREF_6 GTPCD YP24_0 YP24_1 YP24_2
+  YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 YPG26 YPG37
+  VDD VSS Bimod_Tag_ROMMUX_CD_E
.ENDS Bimod_Tag_ROMCD_ROW
****
.SUBCKT Bimod_Tag_ROMCCREF BLREFL BLREFR WL0 WL0P WL1 WL1P VDD VSS
** Bimod_Tag_ROMCCREF: 2 flat devices **
d1 VSS BLREFL NDIO12 0.1271P 1.44U
d2 VSS BLREFR NDIO12 0.1271P 1.44U
.ENDS Bimod_Tag_ROMCCREF
****
.SUBCKT Bimod_Tag_ROMREFSTRAP_COL BLREFL BLREFR WL0P_0 WL0P_1 WL0P_2 WL0P_3
+  WL0_0 WL0_1 WL0_2 WL0_3 WL1P_0 WL1P_1 WL1P_2 WL1P_3 WL1_0 WL1_1 WL1_2 WL1_3
+  VDD VSS
** Bimod_Tag_ROMREFSTRAP_COL: 8 flat devices **
XI0 BLREFL BLREFR WL0_0 WL0P_0 WL1_0 WL1P_0 VDD VSS Bimod_Tag_ROMCCREF
XI1 BLREFL BLREFR WL0_1 WL0P_1 WL1_1 WL1P_1 VDD VSS Bimod_Tag_ROMCCREF
XI2 BLREFL BLREFR WL0_2 WL0P_2 WL1_2 WL1P_2 VDD VSS Bimod_Tag_ROMCCREF
XI3 BLREFL BLREFR WL0_3 WL0P_3 WL1_3 WL1P_3 VDD VSS Bimod_Tag_ROMCCREF
.ENDS Bimod_Tag_ROMREFSTRAP_COL
****
.SUBCKT Bimod_Tag_ROMCC01 BL WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC01: 1 flat devices **
m1 BL WLP0 VSS VSS N12 L=0.13U W=0.31U
.ENDS Bimod_Tag_ROMCC01
****
.SUBCKT Bimod_Tag_ROMCC_PGM_150 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_150: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_150
****
.SUBCKT Bimod_Tag_ROMCC00 BL WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC00: 2 flat devices **
m1 BL WLP1 VSS VSS N12 L=0.13U W=0.31U
m2 BL WLP0 VSS VSS N12 L=0.13U W=0.31U
.ENDS Bimod_Tag_ROMCC00
****
.SUBCKT Bimod_Tag_ROMCC11 BL WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC11: 1 flat devices **
d1 VSS BL NDIO12 0.1271P 1.44U
.ENDS Bimod_Tag_ROMCC11
****
.SUBCKT Bimod_Tag_ROMCC_PGM_179 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_179: 5 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_179
****
.SUBCKT Bimod_Tag_ROMCC_PGM_251 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_251: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_251
****
.SUBCKT Bimod_Tag_ROMCC_PGM_255 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_255: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_255
****
.SUBCKT Bimod_Tag_ROMCC_PGM_159 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_159: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_159
****
.SUBCKT Bimod_Tag_ROMCC_PGM_111 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_111: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_111
****
.SUBCKT Bimod_Tag_ROMCC_PGM_191 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_191: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_191
****
.SUBCKT Bimod_Tag_ROMBIT_COL_5 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_5: 65 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL1_0 WL0_0 WLP1_0 WLP0_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_150
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_179
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_159
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_111
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_191
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_5
****
.SUBCKT Bimod_Tag_ROMCC_PGM_136 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_136: 7 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_136
****
.SUBCKT Bimod_Tag_ROMCC_PGM_128 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_128: 7 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_128
****
.SUBCKT Bimod_Tag_ROMCC_PGM_123 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_123: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_123
****
.SUBCKT Bimod_Tag_ROMCC_PGM_175 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_175: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_175
****
.SUBCKT Bimod_Tag_ROMCC_PGM_47 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_47: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_47
****
.SUBCKT Bimod_Tag_ROMBIT_COL_6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_6: 70 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_136
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_128
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_175
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_47
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_111
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_6
****
.SUBCKT Bimod_Tag_ROMCC_PGM_148 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_148: 5 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_148
****
.SUBCKT Bimod_Tag_ROMCC_PGM_163 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_163: 5 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_163
****
.SUBCKT Bimod_Tag_ROMCC_PGM_143 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_143: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_143
****
.SUBCKT Bimod_Tag_ROMCC_PGM_95 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_95: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_95
****
.SUBCKT Bimod_Tag_ROMBIT_COL_13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_13: 66 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL1_0 WL0_0 WLP1_0 WLP0_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_148
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_163
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_143
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_95
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_175
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_13
****
.SUBCKT Bimod_Tag_ROMCC_PGM_16 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_16: 7 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_16
****
.SUBCKT Bimod_Tag_ROMCC_PGM_31 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_31: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_31
****
.SUBCKT Bimod_Tag_ROMCC_PGM_239 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_239: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_239
****
.SUBCKT Bimod_Tag_ROMBIT_COL_14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_14: 70 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_136
XI0_1 BL_0 BL_1 BL_2 BL_3 WL1_1 WL0_1 WLP1_1 WLP0_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_16
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_31
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_239
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_143
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_14
****
.SUBCKT Bimod_Tag_ROMCC_PGM_10 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_10: 6 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_10
****
.SUBCKT Bimod_Tag_ROMBIT_COL_15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_15: 69 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_10
XI0_1 BL_0 BL_1 BL_2 BL_3 WL1_1 WL0_1 WLP1_1 WLP0_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_16
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_143
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_239
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_175
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_15
****
.SUBCKT Bimod_Tag_ROMCC_COL BL WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3
+  WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3 VDD VSS
** Bimod_Tag_ROMCC_COL: 4 flat devices **
XI0 BL WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS Bimod_Tag_ROMCC11
XI1 BL WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS Bimod_Tag_ROMCC11
XI3 BL WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_COL
****
.SUBCKT Bimod_Tag_ROMCC_CAP_COL BL WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2
+  WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3 VDD VSS
** Bimod_Tag_ROMCC_CAP_COL: 4 flat devices **
XI0 BL WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2
+  WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3 VDD VSS Bimod_Tag_ROMCC_COL
.ENDS Bimod_Tag_ROMCC_CAP_COL
****
.SUBCKT Bimod_Tag_ROMCC_PGM_142 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_142: 5 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_142
****
.SUBCKT Bimod_Tag_ROMCC_PGM_48 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_48: 6 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_48
****
.SUBCKT Bimod_Tag_ROMCC_PGM_127 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_127: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_127
****
.SUBCKT Bimod_Tag_ROMBIT_COL_7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_7: 67 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_142
XI0_1 BL_0 BL_1 BL_2 BL_3 WL1_1 WL0_1 WLP1_1 WLP0_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_48
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_239
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_127
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_95
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_7
****
.SUBCKT Bimod_Tag_ROMCC_PGM_34 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_34: 7 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_34
****
.SUBCKT Bimod_Tag_ROMCC_PGM_197 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_197: 5 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_197
****
.SUBCKT Bimod_Tag_ROMBIT_COL_8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_8: 68 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_34
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_197
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_127
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_143
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_8
****
.SUBCKT Bimod_Tag_ROMCC_PGM_18 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_18: 6 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_18
****
.SUBCKT Bimod_Tag_ROMCC_PGM_147 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_147: 5 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_147
****
.SUBCKT Bimod_Tag_ROMCC_PGM_15 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_15: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_15
****
.SUBCKT Bimod_Tag_ROMBIT_COL_9 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_9: 67 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL1_0 WL0_0 WLP1_0 WLP0_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_18
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_147
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_159
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_15
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_47
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_9
****
.SUBCKT Bimod_Tag_ROMCC_PGM_14 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_14: 5 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_14
****
.SUBCKT Bimod_Tag_ROMCC_PGM_64 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_64: 7 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_64
****
.SUBCKT Bimod_Tag_ROMBIT_COL_10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_10: 68 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_14
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_64
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_95
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_31
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_127
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_10
****
.SUBCKT Bimod_Tag_ROMCC_PGM_202 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_202: 5 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_202
****
.SUBCKT Bimod_Tag_ROMCC_PGM_168 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_168: 6 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_168
****
.SUBCKT Bimod_Tag_ROMBIT_COL_11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_11: 67 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_202
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_168
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_191
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_111
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_95
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_11
****
.SUBCKT Bimod_Tag_ROMCC_PGM_236 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_236: 5 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_236
****
.SUBCKT Bimod_Tag_ROMCC_PGM_93 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_93: 5 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_93
****
.SUBCKT Bimod_Tag_ROMCC_PGM_79 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_79: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_79
****
.SUBCKT Bimod_Tag_ROMCC_PGM_207 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_207: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_207
****
.SUBCKT Bimod_Tag_ROMBIT_COL_12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_12: 66 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_236
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_93
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_79
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_207
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_47
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_12
****
.SUBCKT Bimod_Tag_ROMCC_PGM_32 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_32: 7 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_32
****
.SUBCKT Bimod_Tag_ROMCC_PGM_5 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_5: 6 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_5
****
.SUBCKT Bimod_Tag_ROMBIT_COL_0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_0: 69 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_32
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_5
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_175
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_31
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_175
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_0
****
.SUBCKT Bimod_Tag_ROMCC_PGM_243 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_243: 4 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
.ENDS Bimod_Tag_ROMCC_PGM_243
****
.SUBCKT Bimod_Tag_ROMBIT_COL_1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_1: 64 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL1_0 WL0_0 WLP1_0 WLP0_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_150
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_243
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_175
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_47
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_191
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_1
****
.SUBCKT Bimod_Tag_ROMCC_PGM_240 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_240: 4 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
.ENDS Bimod_Tag_ROMCC_PGM_240
****
.SUBCKT Bimod_Tag_ROMBIT_COL_2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_2: 67 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_136
XI0_1 BL_0 BL_1 BL_2 BL_3 WL1_1 WL0_1 WLP1_1 WLP0_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_240
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_191
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_175
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_159
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_2
****
.SUBCKT Bimod_Tag_ROMCC_PGM_160 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_160: 6 flat devices **
XI0 BL_0 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_160
****
.SUBCKT Bimod_Tag_ROMBIT_COL_3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_3: 68 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_10
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_160
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_123
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_127
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_127
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_207
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_3
****
.SUBCKT Bimod_Tag_ROMCC_PGM_172 BL_0 BL_1 BL_2 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCC_PGM_172: 5 flat devices **
XI0 BL_0 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC11
XI1 BL_1 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC01
XI2 BL_2 WL1 WL0 WLP1 WLP0 VDD VSS Bimod_Tag_ROMCC01
XI3 BL_3 WL0 WL1 WLP0 WLP1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMCC_PGM_172
****
.SUBCKT Bimod_Tag_ROMBIT_COL_4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3
+  VDD VSS
** Bimod_Tag_ROMBIT_COL_4: 66 flat devices **
XI0_0 BL_0 BL_1 BL_2 BL_3 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_172
XI0_1 BL_0 BL_1 BL_2 BL_3 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_197
XI0_2 BL_0 BL_1 BL_2 BL_3 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI0_3 BL_0 BL_1 BL_2 BL_3 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_0 BL_4 BL_5 BL_6 BL_7 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_251
XI1_1 BL_4 BL_5 BL_6 BL_7 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_159
XI1_2 BL_4 BL_5 BL_6 BL_7 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI1_3 BL_4 BL_5 BL_6 BL_7 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_0 BL_8 BL_9 BL_10 BL_11 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_1 BL_8 BL_9 BL_10 BL_11 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_143
XI2_2 BL_8 BL_9 BL_10 BL_11 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI2_3 BL_8 BL_9 BL_10 BL_11 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_0 BL_12 BL_13 BL_14 BL_15 WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_1 BL_12 BL_13 BL_14 BL_15 WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS
+  Bimod_Tag_ROMCC_PGM_143
XI3_2 BL_12 BL_13 BL_14 BL_15 WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
XI3_3 BL_12 BL_13 BL_14 BL_15 WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS
+  Bimod_Tag_ROMCC_PGM_255
.ENDS Bimod_Tag_ROMBIT_COL_4
****
.SUBCKT Bimod_Tag_ROMCC_ROWS BLREFL_0 BLREFL_1 BLREFL_2 BLREFL_3 BLREFL_4
+  BLREFL_5 BLREFL_6 BLREFL_7 BLREFR_0 BLREFR_1 BLREFR_2 BLREFR_3 BLREFR_4
+  BLREFR_5 BLREFR_6 BLREFR_7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL_129 BL_130 BL_131 BL_132 BL_133
+  BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142 BL_143
+  BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152 BL_153
+  BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 BL_160 BL_161 BL_162 BL_163
+  BL_164 BL_165 BL_166 BL_167 BL_168 BL_169 BL_170 BL_171 BL_172 BL_173
+  BL_174 BL_175 BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182 BL_183
+  BL_184 BL_185 BL_186 BL_187 BL_188 BL_189 BL_190 BL_191 BL_192 BL_193
+  BL_194 BL_195 BL_196 BL_197 BL_198 BL_199 BL_200 BL_201 BL_202 BL_203
+  BL_204 BL_205 BL_206 BL_207 BL_208 BL_209 BL_210 BL_211 BL_212 BL_213
+  BL_214 BL_215 BL_216 BL_217 BL_218 BL_219 BL_220 BL_221 BL_222 BL_223
+  BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230 BL_231 BL_232 BL_233
+  BL_234 BL_235 BL_236 BL_237 BL_238 BL_239 BL_240 BL_241 BL_242 BL_243
+  BL_244 BL_245 BL_246 BL_247 BL_248 BL_249 BL_250 BL_251 BL_252 BL_253
+  BL_254 BL_255 BL_256 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 WLP0_0
+  WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3 VDD VSS
** Bimod_Tag_ROMCC_ROWS: 1145 flat devices **
XI0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13
+  BL_14 BL_15 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1
+  WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3 VDD VSS Bimod_Tag_ROMBIT_COL_0
XI1 BLREFL_0 BLREFR_0 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WL0_0 WL0_1 WL0_2 WL0_3
+  WLP1_0 WLP1_1 WLP1_2 WLP1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMREFSTRAP_COL
XI10 BLREFL_3 BLREFR_3 WL0_0 WL0_1 WL0_2 WL0_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMREFSTRAP_COL
XI11 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121
+  BL_122 BL_123 BL_124 BL_125 BL_126 BL_127 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_7
XI12 BL_128 BL_129 BL_130 BL_131 BL_132 BL_133 BL_134 BL_135 BL_136 BL_137
+  BL_138 BL_139 BL_140 BL_141 BL_142 BL_143 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_8
XI13 BLREFL_4 BLREFR_4 WL0_0 WL0_1 WL0_2 WL0_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMREFSTRAP_COL
XI14 BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152 BL_153
+  BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_9
XI15 BL_160 BL_161 BL_162 BL_163 BL_164 BL_165 BL_166 BL_167 BL_168 BL_169
+  BL_170 BL_171 BL_172 BL_173 BL_174 BL_175 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_10
XI16 BLREFL_5 BLREFR_5 WL0_0 WL0_1 WL0_2 WL0_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMREFSTRAP_COL
XI17 BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182 BL_183 BL_184 BL_185
+  BL_186 BL_187 BL_188 BL_189 BL_190 BL_191 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_11
XI18 BL_192 BL_193 BL_194 BL_195 BL_196 BL_197 BL_198 BL_199 BL_200 BL_201
+  BL_202 BL_203 BL_204 BL_205 BL_206 BL_207 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_12
XI19 BLREFL_6 BLREFR_6 WL0_0 WL0_1 WL0_2 WL0_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMREFSTRAP_COL
XI2 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27
+  BL_28 BL_29 BL_30 BL_31 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3
+  WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_1
XI20 BL_208 BL_209 BL_210 BL_211 BL_212 BL_213 BL_214 BL_215 BL_216 BL_217
+  BL_218 BL_219 BL_220 BL_221 BL_222 BL_223 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_13
XI21 BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230 BL_231 BL_232 BL_233
+  BL_234 BL_235 BL_236 BL_237 BL_238 BL_239 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_14
XI22 BLREFL_7 BLREFR_7 WL0_0 WL0_1 WL0_2 WL0_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMREFSTRAP_COL
XI23 BL_240 BL_241 BL_242 BL_243 BL_244 BL_245 BL_246 BL_247 BL_248 BL_249
+  BL_250 BL_251 BL_252 BL_253 BL_254 BL_255 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_15
XI24 BL_256 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 WL0_0 WL0_1 WL0_2
+  WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMCC_CAP_COL
XI3 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43
+  BL_44 BL_45 BL_46 BL_47 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3
+  WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_2
XI4 BLREFL_1 BLREFR_1 WL0_0 WL0_1 WL0_2 WL0_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMREFSTRAP_COL
XI5 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59
+  BL_60 BL_61 BL_62 BL_63 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3
+  WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_3
XI6 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75
+  BL_76 BL_77 BL_78 BL_79 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3
+  WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_4
XI7 BLREFL_2 BLREFR_2 WL0_0 WL0_1 WL0_2 WL0_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0
+  WL1_1 WL1_2 WL1_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS Bimod_Tag_ROMREFSTRAP_COL
XI8 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91
+  BL_92 BL_93 BL_94 BL_95 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3
+  WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_5
XI9 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106
+  BL_107 BL_108 BL_109 BL_110 BL_111 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1
+  WL1_2 WL1_3 WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 VDD VSS
+  Bimod_Tag_ROMBIT_COL_6
.ENDS Bimod_Tag_ROMCC_ROWS
****
.SUBCKT Bimod_Tag_ROMCCMWL BL BLX WL0 WL1 WLP0 WLP1 WLS WPS VDD VSS
** Bimod_Tag_ROMCCMWL: 2 flat devices **
m1 BL WLP1 VSS VSS N12 L=0.13U W=0.31U
m2 BL WLP0 VSS VSS N12 L=0.13U W=0.31U
.ENDS Bimod_Tag_ROMCCMWL
****
.SUBCKT Bimod_Tag_ROMCCMWLSTRAP BLBL BLBR BLTL BLTR WL0 WL1 WLP0 WLP1 VDD VSS
** Bimod_Tag_ROMCCMWLSTRAP: 2 flat devices **
d1 VSS BLTL NDIO12 0.1271P 1.44U
d2 VSS BLTR NDIO12 0.1271P 1.44U
.ENDS Bimod_Tag_ROMCCMWLSTRAP
****
.SUBCKT Bimod_Tag_ROMCC00STRAP BLL BLR WL0 WL0P WL1 WL1P VDD VSS
** Bimod_Tag_ROMCC00STRAP: 4 flat devices **
m1 VSS WL1 BLL VSS N12 L=0.13U W=0.31U
m2 VSS WL0 BLL VSS N12 L=0.13U W=0.31U
m3 VSS WL1 BLR VSS N12 L=0.13U W=0.31U
m4 VSS WL0 BLR VSS N12 L=0.13U W=0.31U
.ENDS Bimod_Tag_ROMCC00STRAP
****
.SUBCKT Bimod_Tag_ROMMODEL_ROW_CAP BLX WLP0_0 WLP0_1 WLP1_0 WLP1_1 VDD VSS
** Bimod_Tag_ROMMODEL_ROW_CAP: 4 flat devices **
XI0_0 VSS BLX VSS VSS WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI0_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMMODEL_ROW_CAP
****
.SUBCKT Bimod_Tag_ROMMODEL_ROW BLBL_0 BLBL_1 BLBL_2 BLBL_3 BLBL_4 BLBL_5
+  BLBL_6 BLBL_7 BLBL_8 BLBR_0 BLBR_1 BLBR_2 BLBR_3 BLBR_4 BLBR_5 BLBR_6
+  BLBR_7 BLBR_8 BLX_0 BLX_1 BLX_2 BLX_3 BLX_4 BLX_5 BLX_6 BLX_7 BLX_8 BLX_9
+  BLX_10 BLX_11 BLX_12 BLX_13 BLX_14 BLX_15 BLX_16 BLX_17 BLX_18 BLX_19
+  BLX_20 BLX_21 BLX_22 BLX_23 BLX_24 BLX_25 BLX_26 BLX_27 BLX_28 BLX_29
+  BLX_30 BLX_31 BLX_32 BLX_33 BLX_34 BLX_35 BLX_36 BLX_37 BLX_38 BLX_39
+  BLX_40 BLX_41 BLX_42 BLX_43 BLX_44 BLX_45 BLX_46 BLX_47 BLX_48 BLX_49
+  BLX_50 BLX_51 BLX_52 BLX_53 BLX_54 BLX_55 BLX_56 BLX_57 BLX_58 BLX_59
+  BLX_60 BLX_61 BLX_62 BLX_63 BLX_64 BLX_65 BLX_66 BLX_67 BLX_68 BLX_69
+  BLX_70 BLX_71 BLX_72 BLX_73 BLX_74 BLX_75 BLX_76 BLX_77 BLX_78 BLX_79
+  BLX_80 BLX_81 BLX_82 BLX_83 BLX_84 BLX_85 BLX_86 BLX_87 BLX_88 BLX_89
+  BLX_90 BLX_91 BLX_92 BLX_93 BLX_94 BLX_95 BLX_96 BLX_97 BLX_98 BLX_99
+  BLX_100 BLX_101 BLX_102 BLX_103 BLX_104 BLX_105 BLX_106 BLX_107 BLX_108
+  BLX_109 BLX_110 BLX_111 BLX_112 BLX_113 BLX_114 BLX_115 BLX_116 BLX_117
+  BLX_118 BLX_119 BLX_120 BLX_121 BLX_122 BLX_123 BLX_124 BLX_125 BLX_126
+  BLX_127 BLX_128 BLX_129 BLX_130 BLX_131 BLX_132 BLX_133 BLX_134 BLX_135
+  BLX_136 BLX_137 BLX_138 BLX_139 BLX_140 BLX_141 BLX_142 BLX_143 BLX_144
+  BLX_145 BLX_146 BLX_147 BLX_148 BLX_149 BLX_150 BLX_151 BLX_152 BLX_153
+  BLX_154 BLX_155 BLX_156 BLX_157 BLX_158 BLX_159 BLX_160 BLX_161 BLX_162
+  BLX_163 BLX_164 BLX_165 BLX_166 BLX_167 BLX_168 BLX_169 BLX_170 BLX_171
+  BLX_172 BLX_173 BLX_174 BLX_175 BLX_176 BLX_177 BLX_178 BLX_179 BLX_180
+  BLX_181 BLX_182 BLX_183 BLX_184 BLX_185 BLX_186 BLX_187 BLX_188 BLX_189
+  BLX_190 BLX_191 BLX_192 BLX_193 BLX_194 BLX_195 BLX_196 BLX_197 BLX_198
+  BLX_199 BLX_200 BLX_201 BLX_202 BLX_203 BLX_204 BLX_205 BLX_206 BLX_207
+  BLX_208 BLX_209 BLX_210 BLX_211 BLX_212 BLX_213 BLX_214 BLX_215 BLX_216
+  BLX_217 BLX_218 BLX_219 BLX_220 BLX_221 BLX_222 BLX_223 BLX_224 BLX_225
+  BLX_226 BLX_227 BLX_228 BLX_229 BLX_230 BLX_231 BLX_232 BLX_233 BLX_234
+  BLX_235 BLX_236 BLX_237 BLX_238 BLX_239 BLX_240 BLX_241 BLX_242 BLX_243
+  BLX_244 BLX_245 BLX_246 BLX_247 BLX_248 BLX_249 BLX_250 BLX_251 BLX_252
+  BLX_253 BLX_254 WL0 WLP0_0 WLP0_1 WLP1_0 WLP1_1 VDD VSS
** Bimod_Tag_ROMMODEL_ROW: 1072 flat devices **
XI0_0 VSS BLX_0 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI0_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI100_0 VSS BLX_97 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI100_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI101_0 VSS BLX_98 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI101_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI102_0 VSS BLX_99 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI102_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI103_0 VSS BLX_100 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI103_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI104_0 VSS BLX_101 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI104_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI105_0 VSS BLX_102 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI105_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI106_0 VSS BLX_103 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI106_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI107_0 VSS BLX_104 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI107_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI108_0 VSS BLX_105 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI108_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI109_0 VSS BLX_106 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI109_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI10_0 VSS BLX_10 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI10_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI110_0 VSS BLX_107 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI110_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI111_0 VSS BLX_108 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI111_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI112_0 VSS BLX_109 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI112_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI113_0 VSS BLX_110 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI113_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI114_0 VSS BLX_111 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI114_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI115_0 BLBL_3 BLBR_3 VSS VSS WL0 WL0 WL0 WL0 VDD VSS Bimod_Tag_ROMCCMWLSTRAP
XI115_1 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00STRAP
XI116_0 VSS BLX_112 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI116_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI117_0 VSS BLX_113 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI117_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI118_0 VSS BLX_114 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI118_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI119_0 VSS BLX_115 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI119_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI11_0 VSS BLX_11 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI11_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI120_0 VSS BLX_116 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI120_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI121_0 VSS BLX_117 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI121_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI122_0 VSS BLX_118 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI122_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI123_0 VSS BLX_119 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI123_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI124_0 VSS BLX_120 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI124_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI125_0 VSS BLX_121 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI125_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI126_0 VSS BLX_122 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI126_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI127_0 VSS BLX_123 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI127_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI128_0 VSS BLX_124 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI128_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI129_0 VSS BLX_125 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI129_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI12_0 VSS BLX_12 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI12_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI130_0 VSS BLX_126 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI130_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI131_0 VSS BLX_127 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI131_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI132_0 VSS BLX_128 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI132_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI133_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI134_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI135_0 VSS BLX_129 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI135_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI136_0 VSS BLX_130 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI136_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI137_0 VSS BLX_131 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI137_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI138_0 VSS BLX_132 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI138_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI139_0 VSS BLX_133 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI139_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI13_0 VSS BLX_13 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI13_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI140_0 VSS BLX_134 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI140_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI141_0 VSS BLX_135 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI141_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI142_0 VSS BLX_136 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI142_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI143_0 VSS BLX_137 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI143_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI144_0 VSS BLX_138 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI144_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI145_0 VSS BLX_139 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI145_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI146_0 VSS BLX_140 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI146_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI147_0 VSS BLX_141 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI147_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI148_0 BLBL_5 BLBR_5 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWLSTRAP
XI148_1 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00STRAP
XI149_0 VSS BLX_142 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI149_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI14_0 VSS BLX_14 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI14_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI150_0 VSS BLX_143 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI150_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI151_0 VSS BLX_144 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI151_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI152_0 VSS BLX_145 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI152_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI153_0 VSS BLX_146 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI153_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI154_0 VSS BLX_147 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI154_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI155_0 VSS BLX_148 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI155_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI156_0 VSS BLX_149 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI156_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI157_0 VSS BLX_150 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI157_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI158_0 VSS BLX_151 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI158_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI159_0 VSS BLX_152 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI159_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI15_0 VSS BLX_15 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI15_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI160_0 VSS BLX_153 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI160_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI161_0 VSS BLX_154 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI161_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI162_0 VSS BLX_155 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI162_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI163_0 VSS BLX_156 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI163_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI164_0 VSS BLX_157 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI164_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI165_0 VSS BLX_158 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI165_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI166_0 VSS BLX_159 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI166_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI167_0 VSS BLX_160 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI167_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI168_0 VSS BLX_161 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI168_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI169_0 VSS BLX_162 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI169_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI16_0 BLBL_0 BLBR_0 VSS VSS WL0 WL0 WLP0_0 WLP1_0 VDD VSS
+  Bimod_Tag_ROMCCMWLSTRAP
XI16_1 VSS VSS VSS WLP0_1 VSS WLP1_1 VDD VSS Bimod_Tag_ROMCC00STRAP
XI170_0 VSS BLX_163 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI170_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI171_0 VSS BLX_164 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI171_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI172_0 VSS BLX_165 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI172_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI173_0 VSS BLX_166 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI173_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI174_0 VSS BLX_167 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI174_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI175_0 VSS BLX_168 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI175_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI176_0 VSS BLX_169 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI176_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI177_0 VSS BLX_170 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI177_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI178_0 VSS BLX_171 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI178_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI179_0 VSS BLX_172 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI179_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI17_0 VSS BLX_16 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI17_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI180_0 VSS BLX_173 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI180_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI181_0 BLBL_6 BLBR_6 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWLSTRAP
XI181_1 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00STRAP
XI182_0 VSS BLX_174 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI182_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI183_0 VSS BLX_175 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI183_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI184_0 VSS BLX_176 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI184_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI185_0 VSS BLX_177 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI185_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI186_0 VSS BLX_178 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI186_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI187_0 VSS BLX_179 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI187_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI188_0 VSS BLX_180 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI188_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI189_0 VSS BLX_181 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI189_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI18_0 VSS BLX_17 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI18_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI190_0 VSS BLX_182 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI190_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI191_0 VSS BLX_183 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI191_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI192_0 VSS BLX_184 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI192_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI193_0 VSS BLX_185 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI193_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI194_0 VSS BLX_186 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI194_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI195_0 VSS BLX_187 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI195_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI196_0 VSS BLX_188 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI196_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI197_0 VSS BLX_189 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI197_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI198_0 VSS BLX_190 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI198_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI199_0 VSS BLX_191 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI199_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI19_0 VSS BLX_18 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI19_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI1_0 VSS BLX_1 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI1_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI200_0 VSS BLX_192 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI200_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI201_0 VSS BLX_193 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI201_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI202_0 VSS BLX_194 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI202_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI203_0 VSS BLX_195 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI203_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI204_0 VSS BLX_196 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI204_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI205_0 VSS BLX_197 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI205_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI206_0 VSS BLX_198 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI206_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI207_0 VSS BLX_199 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI207_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI208_0 VSS BLX_200 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI208_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI209_0 VSS BLX_201 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI209_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI20_0 VSS BLX_19 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI20_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI210_0 VSS BLX_202 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI210_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI211_0 VSS BLX_203 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI211_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI212_0 VSS BLX_204 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI212_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI213_0 VSS BLX_205 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI213_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI214_0 BLBL_7 BLBR_7 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWLSTRAP
XI214_1 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00STRAP
XI215_0 VSS BLX_206 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI215_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI216_0 VSS BLX_207 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI216_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI217_0 VSS BLX_208 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI217_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI218_0 VSS BLX_209 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI218_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI219_0 VSS BLX_210 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI219_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI21_0 VSS BLX_20 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI21_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI220_0 VSS BLX_211 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI220_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI221_0 VSS BLX_212 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI221_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI222_0 VSS BLX_213 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI222_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI223_0 VSS BLX_214 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI223_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI224_0 VSS BLX_215 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI224_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI225_0 VSS BLX_216 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI225_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI226_0 VSS BLX_217 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI226_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI227_0 VSS BLX_218 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI227_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI228_0 VSS BLX_219 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI228_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI229_0 VSS BLX_220 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI229_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI22_0 VSS BLX_21 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI22_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI230_0 VSS BLX_221 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI230_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI231_0 VSS BLX_222 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI231_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI232_0 VSS BLX_223 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI232_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI233_0 VSS BLX_224 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI233_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI234_0 VSS BLX_225 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI234_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI235_0 VSS BLX_226 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI235_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI236_0 VSS BLX_227 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI236_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI237_0 VSS BLX_228 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI237_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI238_0 VSS BLX_229 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI238_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI239_0 VSS BLX_230 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI239_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI23_0 VSS BLX_22 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI23_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI240_0 VSS BLX_231 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI240_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI241_0 VSS BLX_232 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI241_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI242_0 VSS BLX_233 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI242_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI243_0 VSS BLX_234 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI243_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI244_0 VSS BLX_235 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI244_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI245_0 VSS BLX_236 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI245_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI246_0 VSS BLX_237 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI246_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI247_0 BLBL_8 BLBR_8 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWLSTRAP
XI247_1 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00STRAP
XI248_0 VSS BLX_238 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI248_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI249_0 VSS BLX_239 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI249_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI24_0 VSS BLX_23 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI24_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI250_0 VSS BLX_240 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI250_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI251_0 VSS BLX_241 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI251_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI252_0 VSS BLX_242 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI252_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI253_0 VSS BLX_243 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI253_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI254_0 VSS BLX_244 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI254_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI255_0 VSS BLX_245 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI255_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI256_0 VSS BLX_246 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI256_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI257_0 VSS BLX_247 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI257_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI258_0 VSS BLX_248 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI258_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI259_0 VSS BLX_249 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI259_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI25_0 VSS BLX_24 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI25_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI260_0 VSS BLX_250 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI260_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI261_0 VSS BLX_251 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI261_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI262_0 VSS BLX_252 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI262_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI263_0 VSS BLX_253 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI263_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI264_0 BLX_254 VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMMODEL_ROW_CAP
XI26_0 VSS BLX_25 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI26_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI27_0 VSS BLX_26 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI27_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI28_0 VSS BLX_27 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI28_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI29_0 VSS BLX_28 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI29_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI2_0 VSS BLX_2 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI2_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI30_0 VSS BLX_29 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI30_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI31_0 VSS BLX_30 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI31_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI32_0 VSS BLX_31 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI32_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI33_0 VSS BLX_32 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI33_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI34_0 VSS BLX_33 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI34_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI35_0 VSS BLX_34 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI35_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI36_0 VSS BLX_35 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI36_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI37_0 VSS BLX_36 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI37_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI38_0 VSS BLX_37 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI38_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI39_0 VSS BLX_38 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI39_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI3_0 VSS BLX_3 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI3_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI40_0 VSS BLX_39 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI40_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI41_0 VSS BLX_40 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI41_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI42_0 VSS BLX_41 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI42_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI43_0 VSS BLX_42 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI43_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI44_0 VSS BLX_43 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI44_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI45_0 VSS BLX_44 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI45_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI46_0 VSS BLX_45 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI46_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI47_0 VSS BLX_46 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI47_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI48_0 VSS BLX_47 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI48_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI49_0 BLBL_1 BLBR_1 VSS VSS WL0 WL0 WL0 WL0 VDD VSS Bimod_Tag_ROMCCMWLSTRAP
XI49_1 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00STRAP
XI4_0 VSS BLX_4 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI4_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI50_0 VSS BLX_48 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI50_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI51_0 VSS BLX_49 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI51_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI52_0 VSS BLX_50 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI52_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI53_0 VSS BLX_51 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI53_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI54_0 VSS BLX_52 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI54_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI55_0 VSS BLX_53 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI55_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI56_0 VSS BLX_54 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI56_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI57_0 VSS BLX_55 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI57_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI58_0 VSS BLX_56 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI58_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI59_0 VSS BLX_57 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI59_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI5_0 VSS BLX_5 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI5_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI60_0 VSS BLX_58 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI60_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI61_0 VSS BLX_59 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI61_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI62_0 VSS BLX_60 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI62_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI63_0 VSS BLX_61 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI63_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI64_0 VSS BLX_62 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI64_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI65_0 VSS BLX_63 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI65_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI66_0 VSS BLX_64 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI66_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI67_0 VSS BLX_65 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI67_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI68_0 VSS BLX_66 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI68_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI69_0 VSS BLX_67 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI69_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI6_0 VSS BLX_6 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI6_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI70_0 VSS BLX_68 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI70_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI71_0 VSS BLX_69 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI71_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI72_0 VSS BLX_70 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI72_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI73_0 VSS BLX_71 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI73_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI74_0 VSS BLX_72 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI74_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI75_0 VSS BLX_73 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI75_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI76_0 VSS BLX_74 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI76_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI77_0 VSS BLX_75 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI77_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI78_0 VSS BLX_76 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI78_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI79_0 VSS BLX_77 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI79_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI7_0 VSS BLX_7 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI7_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI80_0 VSS BLX_78 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI80_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI81_0 VSS BLX_79 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI81_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI82_0 BLBL_2 BLBR_2 VSS VSS WL0 WL0 WL0 WL0 VDD VSS Bimod_Tag_ROMCCMWLSTRAP
XI82_1 VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00STRAP
XI83_0 VSS BLX_80 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI83_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI84_0 VSS BLX_81 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI84_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI85_0 VSS BLX_82 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI85_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI86_0 VSS BLX_83 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI86_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI87_0 VSS BLX_84 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI87_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI88_0 VSS BLX_85 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI88_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI89_0 VSS BLX_86 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI89_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI8_0 VSS BLX_8 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI8_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI90_0 VSS BLX_87 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI90_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI91_0 VSS BLX_88 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI91_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI92_0 VSS BLX_89 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI92_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI93_0 VSS BLX_90 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI93_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI94_0 VSS BLX_91 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI94_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI95_0 VSS BLX_92 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI95_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI96_0 VSS BLX_93 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI96_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI97_0 VSS BLX_94 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI97_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI98_0 VSS BLX_95 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI98_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI99_0 VSS BLX_96 WL0 WL0 WL0 WL0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI99_1 VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMCC00
XI9_0 VSS BLX_9 WL0 WL0 WLP0_0 WLP1_0 VSS VSS VDD VSS Bimod_Tag_ROMCCMWL
XI9_1 VSS VSS VSS WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMMODEL_ROW
****
.SUBCKT Bimod_Tag_ROMALL_BITS GTP GTPCD Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8
+  Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 WL0_0 WL0_1 WL0_2 WL0_3 WL0_4 WL1_0 WL1_1
+  WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP0_4 WLP0_5 WLP1_0 WLP1_1 WLP1_2
+  WLP1_3 WLP1_4 WLP1_5 YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2
+  YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
** Bimod_Tag_ROMALL_BITS: 8825 flat devices **
XI0 DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11 DB_12 DB_13
+  DB_14 DB_15 GTP Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13
+  Q_14 Q_15 REFDB_0 REFDB_1 REFDB_2 REFDB_3 REFDB_4 REFDB_5 REFDB_6 REFDB_7
+  REFDB_8 REFDB_9 REFDB_10 REFDB_11 REFDB_12 REFDB_13 REFDB_14 REFDB_15 VDD
+  VSS Bimod_Tag_ROMSA_ROW
XI1 B0_0 B0_1 B0_2 B0_3 B0_4 B0_5 B0_6 B0_7 B0_8 B0_9 B0_10 B0_11 B0_12 B0_13
+  B0_14 B0_15 B1_0 B1_1 B1_2 B1_3 B1_4 B1_5 B1_6 B1_7 B1_8 B1_9 B1_10 B1_11
+  B1_12 B1_13 B1_14 B1_15 B2_0 B2_1 B2_2 B2_3 B2_4 B2_5 B2_6 B2_7 B2_8 B2_9
+  B2_10 B2_11 B2_12 B2_13 B2_14 B2_15 B3_0 B3_1 B3_2 B3_3 B3_4 B3_5 B3_6 B3_7
+  B3_8 B3_9 B3_10 B3_11 B3_12 B3_13 B3_14 B3_15 B4_0 B4_1 B4_2 B4_3 B4_4 B4_5
+  B4_6 B4_7 B4_8 B4_9 B4_10 B4_11 B4_12 B4_13 B4_14 B4_15 B5_0 B5_1 B5_2 B5_3
+  B5_4 B5_5 B5_6 B5_7 B5_8 B5_9 B5_10 B5_11 B5_12 B5_13 B5_14 B5_15 B6_0 B6_1
+  B6_2 B6_3 B6_4 B6_5 B6_6 B6_7 B6_8 B6_9 B6_10 B6_11 B6_12 B6_13 B6_14 B6_15
+  B7_0 B7_1 B7_2 B7_3 B7_4 B7_5 B7_6 B7_7 B7_8 B7_9 B7_10 B7_11 B7_12 B7_13
+  B7_14 B7_15 B8_0 B8_1 B8_2 B8_3 B8_4 B8_5 B8_6 B8_7 B8_8 B8_9 B8_10 B8_11
+  B8_12 B8_13 B8_14 B8_15 B9_0 B9_1 B9_2 B9_3 B9_4 B9_5 B9_6 B9_7 B9_8 B9_9
+  B9_10 B9_11 B9_12 B9_13 B9_14 B9_15 B10_0 B10_1 B10_2 B10_3 B10_4 B10_5
+  B10_6 B10_7 B10_8 B10_9 B10_10 B10_11 B10_12 B10_13 B10_14 B10_15 B11_0
+  B11_1 B11_2 B11_3 B11_4 B11_5 B11_6 B11_7 B11_8 B11_9 B11_10 B11_11 B11_12
+  B11_13 B11_14 B11_15 B12_0 B12_1 B12_2 B12_3 B12_4 B12_5 B12_6 B12_7 B12_8
+  B12_9 B12_10 B12_11 B12_12 B12_13 B12_14 B12_15 B13_0 B13_1 B13_2 B13_3
+  B13_4 B13_5 B13_6 B13_7 B13_8 B13_9 B13_10 B13_11 B13_12 B13_13 B13_14
+  B13_15 B14_0 B14_1 B14_2 B14_3 B14_4 B14_5 B14_6 B14_7 B14_8 B14_9 B14_10
+  B14_11 B14_12 B14_13 B14_14 B14_15 B15_0 B15_1 B15_2 B15_3 B15_4 B15_5
+  B15_6 B15_7 B15_8 B15_9 B15_10 B15_11 B15_12 B15_13 B15_14 B15_15 BLLREF_0
+  BLLREF_1 BLLREF_2 BLLREF_3 BLLREF_4 BLLREF_5 BLLREF_6 BLLREF_7 BLRREF_0
+  BLRREF_1 BLRREF_2 BLRREF_3 BLRREF_4 BLRREF_5 BLRREF_6 BLRREF_7 REFDB_0
+  REFDB_1 REFDB_2 REFDB_3 REFDB_4 REFDB_5 REFDB_6 REFDB_7 REFDB_8 REFDB_9
+  REFDB_10 REFDB_11 REFDB_12 REFDB_13 REFDB_14 REFDB_15 DB_0 DB_1 DB_2 DB_3
+  DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11 DB_12 DB_13 DB_14 DB_15 GTPCD
+  YP24_0 YP24_1 YP24_2 YP24_3 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5
+  YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMCD_ROW
XI2 BLLREF_0 BLLREF_1 BLLREF_2 BLLREF_3 BLLREF_4 BLLREF_5 BLLREF_6 BLLREF_7
+  BLRREF_0 BLRREF_1 BLRREF_2 BLRREF_3 BLRREF_4 BLRREF_5 BLRREF_6 BLRREF_7
+  B0_0 B1_0 B2_0 B3_0 B4_0 B5_0 B6_0 B7_0 B8_0 B9_0 B10_0 B11_0 B12_0 B13_0
+  B14_0 B15_0 B15_1 B14_1 B13_1 B12_1 B11_1 B10_1 B9_1 B8_1 B7_1 B6_1 B5_1
+  B4_1 B3_1 B2_1 B1_1 B0_1 B0_2 B1_2 B2_2 B3_2 B4_2 B5_2 B6_2 B7_2 B8_2 B9_2
+  B10_2 B11_2 B12_2 B13_2 B14_2 B15_2 B15_3 B14_3 B13_3 B12_3 B11_3 B10_3
+  B9_3 B8_3 B7_3 B6_3 B5_3 B4_3 B3_3 B2_3 B1_3 B0_3 B0_4 B1_4 B2_4 B3_4 B4_4
+  B5_4 B6_4 B7_4 B8_4 B9_4 B10_4 B11_4 B12_4 B13_4 B14_4 B15_4 B15_5 B14_5
+  B13_5 B12_5 B11_5 B10_5 B9_5 B8_5 B7_5 B6_5 B5_5 B4_5 B3_5 B2_5 B1_5 B0_5
+  B0_6 B1_6 B2_6 B3_6 B4_6 B5_6 B6_6 B7_6 B8_6 B9_6 B10_6 B11_6 B12_6 B13_6
+  B14_6 B15_6 B15_7 B14_7 B13_7 B12_7 B11_7 B10_7 B9_7 B8_7 B7_7 B6_7 B5_7
+  B4_7 B3_7 B2_7 B1_7 B0_7 B0_8 B1_8 B2_8 B3_8 B4_8 B5_8 B6_8 B7_8 B8_8 B9_8
+  B10_8 B11_8 B12_8 B13_8 B14_8 B15_8 B15_9 B14_9 B13_9 B12_9 B11_9 B10_9
+  B9_9 B8_9 B7_9 B6_9 B5_9 B4_9 B3_9 B2_9 B1_9 B0_9 B0_10 B1_10 B2_10 B3_10
+  B4_10 B5_10 B6_10 B7_10 B8_10 B9_10 B10_10 B11_10 B12_10 B13_10 B14_10
+  B15_10 B15_11 B14_11 B13_11 B12_11 B11_11 B10_11 B9_11 B8_11 B7_11 B6_11
+  B5_11 B4_11 B3_11 B2_11 B1_11 B0_11 B0_12 B1_12 B2_12 B3_12 B4_12 B5_12
+  B6_12 B7_12 B8_12 B9_12 B10_12 B11_12 B12_12 B13_12 B14_12 B15_12 B15_13
+  B14_13 B13_13 B12_13 B11_13 B10_13 B9_13 B8_13 B7_13 B6_13 B5_13 B4_13
+  B3_13 B2_13 B1_13 B0_13 B0_14 B1_14 B2_14 B3_14 B4_14 B5_14 B6_14 B7_14
+  B8_14 B9_14 B10_14 B11_14 B12_14 B13_14 B14_14 B15_14 B15_15 B14_15 B13_15
+  B12_15 B11_15 B10_15 B9_15 B8_15 B7_15 B6_15 B5_15 B4_15 B3_15 B2_15 B1_15
+  B0_15 VDD WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1 WL1_2 WL1_3 WLP0_0 WLP0_1
+  WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3 VDD VSS Bimod_Tag_ROMCC_ROWS
XI3 BLLREF_0 BLLREF_1 BLLREF_2 BLLREF_3 B2_8 BLLREF_4 BLLREF_5 BLLREF_6
+  BLLREF_7 BLRREF_0 BLRREF_1 BLRREF_2 BLRREF_3 B1_8 BLRREF_4 BLRREF_5
+  BLRREF_6 BLRREF_7 B0_0 B1_0 B2_0 B3_0 B4_0 B5_0 B6_0 B7_0 B8_0 B9_0 B10_0
+  B11_0 B12_0 B13_0 B14_0 B15_0 B15_1 B14_1 B13_1 B12_1 B11_1 B10_1 B9_1 B8_1
+  B7_1 B6_1 B5_1 B4_1 B3_1 B2_1 B1_1 B0_1 B0_2 B1_2 B2_2 B3_2 B4_2 B5_2 B6_2
+  B7_2 B8_2 B9_2 B10_2 B11_2 B12_2 B13_2 B14_2 B15_2 B15_3 B14_3 B13_3 B12_3
+  B11_3 B10_3 B9_3 B8_3 B7_3 B6_3 B5_3 B4_3 B3_3 B2_3 B1_3 B0_3 B0_4 B1_4
+  B2_4 B3_4 B4_4 B5_4 B6_4 B7_4 B8_4 B9_4 B10_4 B11_4 B12_4 B13_4 B14_4 B15_4
+  B15_5 B14_5 B13_5 B12_5 B11_5 B10_5 B9_5 B8_5 B7_5 B6_5 B5_5 B4_5 B3_5 B2_5
+  B1_5 B0_5 B0_6 B1_6 B2_6 B3_6 B4_6 B5_6 B6_6 B7_6 B8_6 B9_6 B10_6 B11_6
+  B12_6 B13_6 B14_6 B15_6 B15_7 B14_7 B13_7 B12_7 B11_7 B10_7 B9_7 B8_7 B7_7
+  B6_7 B5_7 B4_7 B3_7 B2_7 B1_7 B0_7 B0_8 B3_8 B4_8 B5_8 B6_8 B7_8 B8_8 B9_8
+  B10_8 B11_8 B12_8 B13_8 B14_8 B15_8 B15_9 B14_9 B13_9 B12_9 B11_9 B10_9
+  B9_9 B8_9 B7_9 B6_9 B5_9 B4_9 B3_9 B2_9 B1_9 B0_9 B0_10 B1_10 B2_10 B3_10
+  B4_10 B5_10 B6_10 B7_10 B8_10 B9_10 B10_10 B11_10 B12_10 B13_10 B14_10
+  B15_10 B15_11 B14_11 B13_11 B12_11 B11_11 B10_11 B9_11 B8_11 B7_11 B6_11
+  B5_11 B4_11 B3_11 B2_11 B1_11 B0_11 B0_12 B1_12 B2_12 B3_12 B4_12 B5_12
+  B6_12 B7_12 B8_12 B9_12 B10_12 B11_12 B12_12 B13_12 B14_12 B15_12 B15_13
+  B14_13 B13_13 B12_13 B11_13 B10_13 B9_13 B8_13 B7_13 B6_13 B5_13 B4_13
+  B3_13 B2_13 B1_13 B0_13 B0_14 B1_14 B2_14 B3_14 B4_14 B5_14 B6_14 B7_14
+  B8_14 B9_14 B10_14 B11_14 B12_14 B13_14 B14_14 B15_14 B15_15 B14_15 B13_15
+  B12_15 B11_15 B10_15 B9_15 B8_15 B7_15 B6_15 B5_15 B4_15 B3_15 B2_15 B1_15
+  B0_15 VDD WL0_4 WLP0_4 WLP0_5 WLP1_4 WLP1_5 VDD VSS Bimod_Tag_ROMMODEL_ROW
.ENDS Bimod_Tag_ROMALL_BITS
****
.SUBCKT Bimod_Tag_ROMMODEL_COL BL MWL MWLD WL0_0 WL0_1 WL0_2 WL0_3 WL1_0 WL1_1
+  WL1_2 WL1_3 WLP0_0 WLP0_1 WLP0_2 WLP0_3 WLP1_0 WLP1_1 WLP1_2 WLP1_3 VDD VSS
** Bimod_Tag_ROMMODEL_COL: 8 flat devices **
XI0_0 BL WL0_0 WL1_0 WLP0_0 WLP1_0 VDD VSS Bimod_Tag_ROMCC00
XI0_1 BL WL0_1 WL1_1 WLP0_1 WLP1_1 VDD VSS Bimod_Tag_ROMCC00
XI0_2 BL WL0_2 WL1_2 WLP0_2 WLP1_2 VDD VSS Bimod_Tag_ROMCC00
XI0_3 BL WL0_3 WL1_3 WLP0_3 WLP1_3 VDD VSS Bimod_Tag_ROMCC00
.ENDS Bimod_Tag_ROMMODEL_COL
****
.SUBCKT Bimod_Tag_ROM Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6]
+  Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+  VDD VSS
** Bimod_Tag_ROM: 9593 flat devices **
XI0_0 A[4] A[3] A[0] A[5] A[1] A[6] A[2] AGTPT AGTPT XP_0 XP_1 XP_2 XP_3 XP_4
+  XP_5 XP_6 XP_7 YP24_0 YP24_1 YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5
+  YP38_6 YP38_7 VDD VSS Bimod_Tag_ROMXYDECS
XI1_3 GTP MBL MWLD MWLD WL0_0 WL0_1 WL1_0 WL1_1 WL2_0 WL2_1 WL3_0 WL3_1 XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 VDD VDD VDD VSS Bimod_Tag_ROMWDSTACK
XI3_0 CEN CLK GSRCN GTP GTPN MBL RST VDD VSS Bimod_Tag_ROMHBFX
XI3_1 CLK GSRCN GTPN GTP GTP GTP GTP AGTPT RST YP24_0 YP24_1 VSS VSS YP38_0
+  YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6 YP38_7 VDD VSS
+  Bimod_Tag_ROMCLK_DRVS
XI5_3 MBL MWLD MWLD WL1_0 WL3_0 WL2_1 WL0_1 WL0_0 WL2_0 WL3_1 WL1_1 VSS VSS
+  VSS VSS VSS VSS VSS VSS VDD VSS Bimod_Tag_ROMMODEL_COL
XI6_0 GTP GTP Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11]
+  Q[12] Q[13] Q[14] Q[15] WL1_0 WL3_0 WL2_1 WL0_1 MWLD WL0_0 WL2_0 WL3_1
+  WL1_1 WL1_0 WL3_0 WL2_1 WL0_1 MWLD VSS WL0_0 WL2_0 WL3_1 WL1_1 MWLD VSS
+  YP24_0 YP24_1 VSS VSS YP38_0 YP38_1 YP38_2 YP38_3 YP38_4 YP38_5 YP38_6
+  YP38_7 VDD VSS Bimod_Tag_ROMALL_BITS
.ENDS Bimod_Tag_ROM
